VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO newdene
  CLASS BLOCK ;
  FOREIGN newdene ;
  ORIGIN 2.950 87.900 ;
  SIZE 110.500 BY 123.600 ;
  OBS
      LAYER nwell ;
        RECT 15.700 34.300 73.300 35.600 ;
        RECT 15.700 32.800 19.100 34.300 ;
        RECT 26.400 32.800 29.800 34.300 ;
        RECT 37.100 32.800 40.500 34.300 ;
        RECT 47.800 32.800 51.200 34.300 ;
        RECT 58.500 32.800 61.900 34.300 ;
        RECT 69.200 32.800 72.600 34.300 ;
        RECT 0.600 19.100 82.100 26.000 ;
        RECT 1.100 5.900 81.600 11.500 ;
        RECT 51.050 -36.250 55.650 -35.700 ;
        RECT 51.050 -38.550 58.950 -36.250 ;
        RECT 56.600 -38.750 58.950 -38.550 ;
        RECT 4.550 -46.750 6.450 -41.250 ;
        RECT 56.600 -41.300 59.000 -38.750 ;
        RECT 63.650 -41.300 76.750 -35.200 ;
        RECT 4.550 -50.850 10.150 -46.750 ;
        RECT 18.350 -49.300 24.050 -41.300 ;
        RECT 41.250 -43.650 44.350 -41.350 ;
        RECT 56.600 -42.050 76.750 -41.300 ;
        RECT 56.600 -43.350 80.250 -42.050 ;
        RECT 4.550 -52.200 10.200 -50.850 ;
        RECT 12.850 -52.200 24.200 -50.850 ;
        RECT 4.550 -53.850 6.450 -52.200 ;
        RECT 13.750 -57.800 24.200 -52.200 ;
        RECT 27.150 -60.050 30.650 -46.900 ;
        RECT 34.400 -58.000 39.200 -45.100 ;
        RECT 41.250 -48.000 46.550 -43.650 ;
        RECT 56.600 -48.100 80.700 -43.350 ;
        RECT 56.600 -48.150 63.800 -48.100 ;
        RECT 41.300 -54.850 47.200 -50.450 ;
        RECT 41.300 -58.150 45.200 -54.850 ;
        RECT 61.950 -55.250 65.550 -53.650 ;
        RECT 41.750 -59.550 45.150 -58.150 ;
        RECT 53.800 -61.400 58.100 -59.100 ;
        RECT 61.950 -59.600 63.800 -55.250 ;
        RECT 19.750 -77.000 31.150 -74.200 ;
        RECT 8.650 -77.050 31.150 -77.000 ;
        RECT 8.600 -81.550 31.150 -77.050 ;
        RECT 34.400 -77.800 39.200 -70.700 ;
        RECT 41.200 -76.650 46.000 -69.500 ;
        RECT 8.600 -84.650 33.350 -81.550 ;
        RECT 41.200 -81.650 48.100 -76.650 ;
      LAYER li1 ;
        RECT 12.600 35.600 14.900 35.700 ;
        RECT 21.000 35.600 23.300 35.700 ;
        RECT 32.700 35.600 35.000 35.700 ;
        RECT 42.100 35.600 44.400 35.700 ;
        RECT 53.900 35.600 56.200 35.700 ;
        RECT 64.400 35.600 66.700 35.700 ;
        RECT 11.900 34.500 73.300 35.600 ;
        RECT 16.100 34.100 16.300 34.500 ;
        RECT 17.700 34.100 17.900 34.500 ;
        RECT 26.800 34.100 27.000 34.500 ;
        RECT 28.400 34.100 28.600 34.500 ;
        RECT 37.500 34.100 37.700 34.500 ;
        RECT 39.100 34.100 39.300 34.500 ;
        RECT 48.200 34.100 48.400 34.500 ;
        RECT 49.800 34.100 50.000 34.500 ;
        RECT 58.900 34.100 59.100 34.500 ;
        RECT 60.500 34.100 60.700 34.500 ;
        RECT 69.600 34.100 69.800 34.500 ;
        RECT 71.200 34.100 71.400 34.500 ;
        RECT 16.000 33.100 16.400 34.100 ;
        RECT 16.800 33.100 17.200 34.100 ;
        RECT 17.600 33.100 18.000 34.100 ;
        RECT 18.400 33.100 18.800 34.100 ;
        RECT 26.700 33.100 27.100 34.100 ;
        RECT 27.500 33.100 27.900 34.100 ;
        RECT 28.300 33.100 28.700 34.100 ;
        RECT 29.100 33.100 29.500 34.100 ;
        RECT 37.400 33.100 37.800 34.100 ;
        RECT 38.200 33.100 38.600 34.100 ;
        RECT 39.000 33.100 39.400 34.100 ;
        RECT 39.800 33.100 40.200 34.100 ;
        RECT 48.100 33.100 48.500 34.100 ;
        RECT 48.900 33.100 49.300 34.100 ;
        RECT 49.700 33.100 50.100 34.100 ;
        RECT 50.500 33.100 50.900 34.100 ;
        RECT 58.800 33.100 59.200 34.100 ;
        RECT 59.600 33.100 60.000 34.100 ;
        RECT 60.400 33.100 60.800 34.100 ;
        RECT 61.200 33.100 61.600 34.100 ;
        RECT 69.500 33.100 69.900 34.100 ;
        RECT 70.300 33.100 70.700 34.100 ;
        RECT 71.100 33.100 71.500 34.100 ;
        RECT 71.900 33.100 72.300 34.100 ;
        RECT 16.200 32.400 16.600 32.800 ;
        RECT 16.900 32.700 17.100 33.100 ;
        RECT 18.500 32.900 18.700 33.100 ;
        RECT 17.800 32.700 18.200 32.800 ;
        RECT 18.500 32.700 19.900 32.900 ;
        RECT 16.900 32.500 18.200 32.700 ;
        RECT 17.700 32.400 18.200 32.500 ;
        RECT 19.400 32.400 19.900 32.700 ;
        RECT 26.900 32.400 27.300 32.800 ;
        RECT 27.600 32.700 27.800 33.100 ;
        RECT 29.200 32.900 29.400 33.100 ;
        RECT 28.500 32.700 28.900 32.800 ;
        RECT 29.200 32.700 30.600 32.900 ;
        RECT 27.600 32.500 28.900 32.700 ;
        RECT 28.400 32.400 28.900 32.500 ;
        RECT 30.100 32.400 30.600 32.700 ;
        RECT 37.600 32.400 38.000 32.800 ;
        RECT 38.300 32.700 38.500 33.100 ;
        RECT 39.900 32.900 40.100 33.100 ;
        RECT 39.200 32.700 39.600 32.800 ;
        RECT 39.900 32.700 41.300 32.900 ;
        RECT 38.300 32.500 39.600 32.700 ;
        RECT 39.100 32.400 39.600 32.500 ;
        RECT 40.800 32.400 41.300 32.700 ;
        RECT 48.300 32.400 48.700 32.800 ;
        RECT 49.000 32.700 49.200 33.100 ;
        RECT 50.600 32.900 50.800 33.100 ;
        RECT 49.900 32.700 50.300 32.800 ;
        RECT 50.600 32.700 52.000 32.900 ;
        RECT 49.000 32.500 50.300 32.700 ;
        RECT 49.800 32.400 50.300 32.500 ;
        RECT 51.500 32.400 52.000 32.700 ;
        RECT 59.000 32.400 59.400 32.800 ;
        RECT 59.700 32.700 59.900 33.100 ;
        RECT 61.300 32.900 61.500 33.100 ;
        RECT 60.600 32.700 61.000 32.800 ;
        RECT 61.300 32.700 62.700 32.900 ;
        RECT 59.700 32.500 61.000 32.700 ;
        RECT 60.500 32.400 61.000 32.500 ;
        RECT 62.200 32.400 62.700 32.700 ;
        RECT 69.700 32.400 70.100 32.800 ;
        RECT 70.400 32.700 70.600 33.100 ;
        RECT 72.000 32.900 72.200 33.100 ;
        RECT 71.300 32.700 71.700 32.800 ;
        RECT 72.000 32.700 73.400 32.900 ;
        RECT 70.400 32.500 71.700 32.700 ;
        RECT 71.200 32.400 71.700 32.500 ;
        RECT 72.900 32.400 73.400 32.700 ;
        RECT 17.000 31.900 17.400 32.300 ;
        RECT 17.700 31.700 17.900 32.400 ;
        RECT 19.400 31.700 19.600 32.400 ;
        RECT 27.700 31.900 28.100 32.300 ;
        RECT 28.400 31.700 28.600 32.400 ;
        RECT 30.100 31.700 30.300 32.400 ;
        RECT 38.400 31.900 38.800 32.300 ;
        RECT 39.100 31.700 39.300 32.400 ;
        RECT 40.800 31.700 41.000 32.400 ;
        RECT 49.100 31.900 49.500 32.300 ;
        RECT 49.800 31.700 50.000 32.400 ;
        RECT 51.500 31.700 51.700 32.400 ;
        RECT 59.800 31.900 60.200 32.300 ;
        RECT 60.500 31.700 60.700 32.400 ;
        RECT 62.200 31.700 62.400 32.400 ;
        RECT 70.500 31.900 70.900 32.300 ;
        RECT 71.200 31.700 71.400 32.400 ;
        RECT 72.900 31.700 73.100 32.400 ;
        RECT 16.000 31.200 16.400 31.700 ;
        RECT 16.800 31.200 17.200 31.700 ;
        RECT 17.600 31.200 18.000 31.700 ;
        RECT 18.500 31.200 18.900 31.700 ;
        RECT 19.300 31.200 19.700 31.700 ;
        RECT 26.700 31.200 27.100 31.700 ;
        RECT 27.500 31.200 27.900 31.700 ;
        RECT 28.300 31.200 28.700 31.700 ;
        RECT 29.200 31.200 29.600 31.700 ;
        RECT 30.000 31.200 30.400 31.700 ;
        RECT 37.400 31.200 37.800 31.700 ;
        RECT 38.200 31.200 38.600 31.700 ;
        RECT 39.000 31.200 39.400 31.700 ;
        RECT 39.900 31.200 40.300 31.700 ;
        RECT 40.700 31.200 41.100 31.700 ;
        RECT 48.100 31.200 48.500 31.700 ;
        RECT 48.900 31.200 49.300 31.700 ;
        RECT 49.700 31.200 50.100 31.700 ;
        RECT 50.600 31.200 51.000 31.700 ;
        RECT 51.400 31.200 51.800 31.700 ;
        RECT 58.800 31.200 59.200 31.700 ;
        RECT 59.600 31.200 60.000 31.700 ;
        RECT 60.400 31.200 60.800 31.700 ;
        RECT 61.300 31.200 61.700 31.700 ;
        RECT 62.100 31.200 62.500 31.700 ;
        RECT 69.500 31.200 69.900 31.700 ;
        RECT 70.300 31.200 70.700 31.700 ;
        RECT 71.100 31.200 71.500 31.700 ;
        RECT 72.000 31.200 72.400 31.700 ;
        RECT 72.800 31.200 73.200 31.700 ;
        RECT 16.100 30.800 16.300 31.200 ;
        RECT 18.600 30.800 18.800 31.200 ;
        RECT 26.800 30.800 27.000 31.200 ;
        RECT 29.300 30.800 29.500 31.200 ;
        RECT 37.500 30.800 37.700 31.200 ;
        RECT 40.000 30.800 40.200 31.200 ;
        RECT 48.200 30.800 48.400 31.200 ;
        RECT 50.700 30.800 50.900 31.200 ;
        RECT 58.900 30.800 59.100 31.200 ;
        RECT 61.400 30.800 61.600 31.200 ;
        RECT 69.600 30.800 69.800 31.200 ;
        RECT 72.100 30.800 72.300 31.200 ;
        RECT 0.600 29.700 82.100 30.800 ;
        RECT 1.000 28.700 1.200 29.700 ;
        RECT 2.900 28.700 3.100 29.700 ;
        RECT 7.000 28.700 7.200 29.700 ;
        RECT 8.700 28.700 8.900 29.700 ;
        RECT 9.600 28.700 9.800 29.700 ;
        RECT 11.500 28.700 11.700 29.700 ;
        RECT 15.600 28.700 15.800 29.700 ;
        RECT 17.300 28.700 17.500 29.700 ;
        RECT 20.300 28.700 20.500 29.700 ;
        RECT 22.200 28.700 22.400 29.700 ;
        RECT 26.300 28.700 26.500 29.700 ;
        RECT 28.000 28.700 28.200 29.700 ;
        RECT 31.000 28.700 31.200 29.700 ;
        RECT 32.900 28.700 33.100 29.700 ;
        RECT 37.000 28.700 37.200 29.700 ;
        RECT 38.700 28.700 38.900 29.700 ;
        RECT 41.700 28.700 41.900 29.700 ;
        RECT 43.600 28.700 43.800 29.700 ;
        RECT 47.700 28.700 47.900 29.700 ;
        RECT 49.400 28.700 49.600 29.700 ;
        RECT 52.400 28.700 52.600 29.700 ;
        RECT 54.300 28.700 54.500 29.700 ;
        RECT 58.400 28.700 58.600 29.700 ;
        RECT 60.100 28.700 60.300 29.700 ;
        RECT 63.100 28.700 63.300 29.700 ;
        RECT 65.000 28.700 65.200 29.700 ;
        RECT 69.100 28.700 69.300 29.700 ;
        RECT 70.800 28.700 71.000 29.700 ;
        RECT 73.800 28.700 74.000 29.700 ;
        RECT 75.700 28.700 75.900 29.700 ;
        RECT 79.800 28.700 80.000 29.700 ;
        RECT 81.500 28.700 81.700 29.700 ;
        RECT 0.900 27.900 1.300 28.700 ;
        RECT 1.700 27.900 2.100 28.700 ;
        RECT 2.800 27.900 3.200 28.700 ;
        RECT 3.600 27.900 4.000 28.700 ;
        RECT 4.400 27.900 4.800 28.700 ;
        RECT 5.300 27.900 5.700 28.700 ;
        RECT 6.100 27.900 6.500 28.700 ;
        RECT 6.900 27.900 7.300 28.700 ;
        RECT 7.800 27.900 8.200 28.700 ;
        RECT 8.600 27.900 9.000 28.700 ;
        RECT 9.500 27.900 9.900 28.700 ;
        RECT 10.300 27.900 10.700 28.700 ;
        RECT 11.400 27.900 11.800 28.700 ;
        RECT 12.200 27.900 12.600 28.700 ;
        RECT 13.000 27.900 13.400 28.700 ;
        RECT 13.900 27.900 14.300 28.700 ;
        RECT 14.700 27.900 15.100 28.700 ;
        RECT 15.500 27.900 15.900 28.700 ;
        RECT 16.400 27.900 16.800 28.700 ;
        RECT 17.200 27.900 17.600 28.700 ;
        RECT 20.200 27.900 20.600 28.700 ;
        RECT 21.000 27.900 21.400 28.700 ;
        RECT 22.100 27.900 22.500 28.700 ;
        RECT 22.900 27.900 23.300 28.700 ;
        RECT 23.700 27.900 24.100 28.700 ;
        RECT 24.600 27.900 25.000 28.700 ;
        RECT 25.400 27.900 25.800 28.700 ;
        RECT 26.200 27.900 26.600 28.700 ;
        RECT 27.100 27.900 27.500 28.700 ;
        RECT 27.900 27.900 28.300 28.700 ;
        RECT 30.900 27.900 31.300 28.700 ;
        RECT 31.700 27.900 32.100 28.700 ;
        RECT 32.800 27.900 33.200 28.700 ;
        RECT 33.600 27.900 34.000 28.700 ;
        RECT 34.400 27.900 34.800 28.700 ;
        RECT 35.300 27.900 35.700 28.700 ;
        RECT 36.100 27.900 36.500 28.700 ;
        RECT 36.900 27.900 37.300 28.700 ;
        RECT 37.800 27.900 38.200 28.700 ;
        RECT 38.600 27.900 39.000 28.700 ;
        RECT 41.600 27.900 42.000 28.700 ;
        RECT 42.400 27.900 42.800 28.700 ;
        RECT 43.500 27.900 43.900 28.700 ;
        RECT 44.300 27.900 44.700 28.700 ;
        RECT 45.100 27.900 45.500 28.700 ;
        RECT 46.000 27.900 46.400 28.700 ;
        RECT 46.800 27.900 47.200 28.700 ;
        RECT 47.600 27.900 48.000 28.700 ;
        RECT 48.500 27.900 48.900 28.700 ;
        RECT 49.300 27.900 49.700 28.700 ;
        RECT 52.300 27.900 52.700 28.700 ;
        RECT 53.100 27.900 53.500 28.700 ;
        RECT 54.200 27.900 54.600 28.700 ;
        RECT 55.000 27.900 55.400 28.700 ;
        RECT 55.800 27.900 56.200 28.700 ;
        RECT 56.700 27.900 57.100 28.700 ;
        RECT 57.500 27.900 57.900 28.700 ;
        RECT 58.300 27.900 58.700 28.700 ;
        RECT 59.200 27.900 59.600 28.700 ;
        RECT 60.000 27.900 60.400 28.700 ;
        RECT 63.000 27.900 63.400 28.700 ;
        RECT 63.800 27.900 64.200 28.700 ;
        RECT 64.900 27.900 65.300 28.700 ;
        RECT 65.700 27.900 66.100 28.700 ;
        RECT 66.500 27.900 66.900 28.700 ;
        RECT 67.400 27.900 67.800 28.700 ;
        RECT 68.200 27.900 68.600 28.700 ;
        RECT 69.000 27.900 69.400 28.700 ;
        RECT 69.900 27.900 70.300 28.700 ;
        RECT 70.700 27.900 71.100 28.700 ;
        RECT 73.700 27.900 74.100 28.700 ;
        RECT 74.500 27.900 74.900 28.700 ;
        RECT 75.600 27.900 76.000 28.700 ;
        RECT 76.400 27.900 76.800 28.700 ;
        RECT 77.200 27.900 77.600 28.700 ;
        RECT 78.100 27.900 78.500 28.700 ;
        RECT 78.900 27.900 79.300 28.700 ;
        RECT 79.700 27.900 80.100 28.700 ;
        RECT 80.600 27.900 81.000 28.700 ;
        RECT 81.400 27.900 81.800 28.700 ;
        RECT 1.200 27.000 1.600 27.100 ;
        RECT 1.000 26.700 1.600 27.000 ;
        RECT 1.800 26.700 2.000 27.900 ;
        RECT 3.800 27.200 4.200 27.600 ;
        RECT 4.500 26.800 4.700 27.900 ;
        RECT 5.400 26.800 5.600 27.900 ;
        RECT 6.700 27.300 7.100 27.400 ;
        RECT 7.900 27.300 8.100 27.900 ;
        RECT 6.700 27.100 8.100 27.300 ;
        RECT 6.700 27.000 7.100 27.100 ;
        RECT 1.000 25.700 1.200 26.700 ;
        RECT 1.800 26.300 2.500 26.700 ;
        RECT 1.800 25.700 2.000 26.300 ;
        RECT 4.500 26.200 5.600 26.800 ;
        RECT 4.500 25.700 4.700 26.200 ;
        RECT 5.400 25.700 5.600 26.200 ;
        RECT 7.900 25.700 8.100 27.100 ;
        RECT 8.400 27.000 8.800 27.400 ;
        RECT 9.800 26.700 10.200 27.100 ;
        RECT 10.400 26.700 10.600 27.900 ;
        RECT 12.400 27.200 12.800 27.600 ;
        RECT 13.100 26.800 13.300 27.900 ;
        RECT 14.000 26.800 14.200 27.900 ;
        RECT 15.300 27.300 15.700 27.400 ;
        RECT 16.500 27.300 16.700 27.900 ;
        RECT 15.300 27.100 16.700 27.300 ;
        RECT 15.300 27.000 15.700 27.100 ;
        RECT 10.400 26.300 11.100 26.700 ;
        RECT 10.400 25.700 10.600 26.300 ;
        RECT 13.100 26.200 14.200 26.800 ;
        RECT 13.100 25.700 13.300 26.200 ;
        RECT 14.000 25.700 14.200 26.200 ;
        RECT 16.500 25.700 16.700 27.100 ;
        RECT 17.000 27.000 17.400 27.400 ;
        RECT 20.500 26.700 20.900 27.100 ;
        RECT 21.100 26.700 21.300 27.900 ;
        RECT 23.100 27.200 23.500 27.600 ;
        RECT 23.800 26.800 24.000 27.900 ;
        RECT 24.700 26.800 24.900 27.900 ;
        RECT 26.000 27.300 26.400 27.400 ;
        RECT 27.200 27.300 27.400 27.900 ;
        RECT 26.000 27.100 27.400 27.300 ;
        RECT 26.000 27.000 26.400 27.100 ;
        RECT 21.100 26.300 21.800 26.700 ;
        RECT 21.100 25.700 21.300 26.300 ;
        RECT 23.800 26.200 24.900 26.800 ;
        RECT 23.800 25.700 24.000 26.200 ;
        RECT 24.700 25.700 24.900 26.200 ;
        RECT 27.200 25.700 27.400 27.100 ;
        RECT 27.700 27.000 28.100 27.400 ;
        RECT 31.200 26.700 31.600 27.100 ;
        RECT 31.800 26.700 32.000 27.900 ;
        RECT 33.800 27.200 34.200 27.600 ;
        RECT 34.500 26.800 34.700 27.900 ;
        RECT 35.400 26.800 35.600 27.900 ;
        RECT 36.700 27.300 37.100 27.400 ;
        RECT 37.900 27.300 38.100 27.900 ;
        RECT 36.700 27.100 38.100 27.300 ;
        RECT 36.700 27.000 37.100 27.100 ;
        RECT 31.800 26.300 32.500 26.700 ;
        RECT 31.800 25.700 32.000 26.300 ;
        RECT 34.500 26.200 35.600 26.800 ;
        RECT 34.500 25.700 34.700 26.200 ;
        RECT 35.400 25.700 35.600 26.200 ;
        RECT 37.900 25.700 38.100 27.100 ;
        RECT 38.400 27.000 38.800 27.400 ;
        RECT 41.900 26.700 42.300 27.100 ;
        RECT 42.500 26.700 42.700 27.900 ;
        RECT 44.500 27.200 44.900 27.600 ;
        RECT 45.200 26.800 45.400 27.900 ;
        RECT 46.100 26.800 46.300 27.900 ;
        RECT 47.400 27.300 47.800 27.400 ;
        RECT 48.600 27.300 48.800 27.900 ;
        RECT 47.400 27.100 48.800 27.300 ;
        RECT 47.400 27.000 47.800 27.100 ;
        RECT 42.500 26.300 43.200 26.700 ;
        RECT 42.500 25.700 42.700 26.300 ;
        RECT 45.200 26.200 46.300 26.800 ;
        RECT 45.200 25.700 45.400 26.200 ;
        RECT 46.100 25.700 46.300 26.200 ;
        RECT 48.600 25.700 48.800 27.100 ;
        RECT 49.100 27.000 49.500 27.400 ;
        RECT 52.600 26.700 53.000 27.100 ;
        RECT 53.200 26.700 53.400 27.900 ;
        RECT 55.200 27.200 55.600 27.600 ;
        RECT 55.900 26.800 56.100 27.900 ;
        RECT 56.800 26.800 57.000 27.900 ;
        RECT 58.100 27.300 58.500 27.400 ;
        RECT 59.300 27.300 59.500 27.900 ;
        RECT 58.100 27.100 59.500 27.300 ;
        RECT 58.100 27.000 58.500 27.100 ;
        RECT 53.200 26.300 53.900 26.700 ;
        RECT 53.200 25.700 53.400 26.300 ;
        RECT 55.900 26.200 57.000 26.800 ;
        RECT 55.900 25.700 56.100 26.200 ;
        RECT 56.800 25.700 57.000 26.200 ;
        RECT 59.300 25.700 59.500 27.100 ;
        RECT 59.800 27.000 60.200 27.400 ;
        RECT 63.300 26.700 63.700 27.100 ;
        RECT 63.900 26.700 64.100 27.900 ;
        RECT 65.900 27.200 66.300 27.600 ;
        RECT 66.600 26.800 66.800 27.900 ;
        RECT 67.500 26.800 67.700 27.900 ;
        RECT 68.800 27.300 69.200 27.400 ;
        RECT 70.000 27.300 70.200 27.900 ;
        RECT 68.800 27.100 70.200 27.300 ;
        RECT 68.800 27.000 69.200 27.100 ;
        RECT 63.900 26.300 64.600 26.700 ;
        RECT 63.900 25.700 64.100 26.300 ;
        RECT 66.600 26.200 67.700 26.800 ;
        RECT 66.600 25.700 66.800 26.200 ;
        RECT 67.500 25.700 67.700 26.200 ;
        RECT 70.000 25.700 70.200 27.100 ;
        RECT 70.500 27.000 70.900 27.400 ;
        RECT 74.000 26.700 74.400 27.100 ;
        RECT 74.600 26.700 74.800 27.900 ;
        RECT 76.600 27.200 77.000 27.600 ;
        RECT 77.300 26.800 77.500 27.900 ;
        RECT 78.200 26.800 78.400 27.900 ;
        RECT 79.500 27.300 79.900 27.400 ;
        RECT 80.700 27.300 80.900 27.900 ;
        RECT 79.500 27.100 80.900 27.300 ;
        RECT 79.500 27.000 79.900 27.100 ;
        RECT 74.600 26.300 75.300 26.700 ;
        RECT 74.600 25.700 74.800 26.300 ;
        RECT 77.300 26.200 78.400 26.800 ;
        RECT 77.300 25.700 77.500 26.200 ;
        RECT 78.200 25.700 78.400 26.200 ;
        RECT 80.700 25.700 80.900 27.100 ;
        RECT 81.200 27.000 81.600 27.400 ;
        RECT 0.900 23.400 1.300 25.700 ;
        RECT 1.700 23.400 2.100 25.700 ;
        RECT 2.800 23.400 3.200 25.700 ;
        RECT 3.600 23.400 4.000 25.700 ;
        RECT 4.400 23.400 4.800 25.700 ;
        RECT 5.300 23.400 5.700 25.700 ;
        RECT 6.100 23.400 6.500 25.700 ;
        RECT 6.900 23.400 7.300 25.700 ;
        RECT 7.800 23.400 8.200 25.700 ;
        RECT 8.600 23.400 9.000 25.700 ;
        RECT 9.500 23.400 9.900 25.700 ;
        RECT 10.300 23.400 10.700 25.700 ;
        RECT 11.400 23.400 11.800 25.700 ;
        RECT 12.200 23.400 12.600 25.700 ;
        RECT 13.000 23.400 13.400 25.700 ;
        RECT 13.900 23.400 14.300 25.700 ;
        RECT 14.700 23.400 15.100 25.700 ;
        RECT 15.500 23.400 15.900 25.700 ;
        RECT 16.400 23.400 16.800 25.700 ;
        RECT 17.200 23.400 17.600 25.700 ;
        RECT 20.200 23.400 20.600 25.700 ;
        RECT 21.000 23.400 21.400 25.700 ;
        RECT 22.100 23.400 22.500 25.700 ;
        RECT 22.900 23.400 23.300 25.700 ;
        RECT 23.700 23.400 24.100 25.700 ;
        RECT 24.600 23.400 25.000 25.700 ;
        RECT 25.400 23.400 25.800 25.700 ;
        RECT 26.200 23.400 26.600 25.700 ;
        RECT 27.100 23.400 27.500 25.700 ;
        RECT 27.900 23.400 28.300 25.700 ;
        RECT 30.900 23.400 31.300 25.700 ;
        RECT 31.700 23.400 32.100 25.700 ;
        RECT 32.800 23.400 33.200 25.700 ;
        RECT 33.600 23.400 34.000 25.700 ;
        RECT 34.400 23.400 34.800 25.700 ;
        RECT 35.300 23.400 35.700 25.700 ;
        RECT 36.100 23.400 36.500 25.700 ;
        RECT 36.900 23.400 37.300 25.700 ;
        RECT 37.800 23.400 38.200 25.700 ;
        RECT 38.600 23.400 39.000 25.700 ;
        RECT 41.600 23.400 42.000 25.700 ;
        RECT 42.400 23.400 42.800 25.700 ;
        RECT 43.500 23.400 43.900 25.700 ;
        RECT 44.300 23.400 44.700 25.700 ;
        RECT 45.100 23.400 45.500 25.700 ;
        RECT 46.000 23.400 46.400 25.700 ;
        RECT 46.800 23.400 47.200 25.700 ;
        RECT 47.600 23.400 48.000 25.700 ;
        RECT 48.500 23.400 48.900 25.700 ;
        RECT 49.300 23.400 49.700 25.700 ;
        RECT 52.300 23.400 52.700 25.700 ;
        RECT 53.100 23.400 53.500 25.700 ;
        RECT 54.200 23.400 54.600 25.700 ;
        RECT 55.000 23.400 55.400 25.700 ;
        RECT 55.800 23.400 56.200 25.700 ;
        RECT 56.700 23.400 57.100 25.700 ;
        RECT 57.500 23.400 57.900 25.700 ;
        RECT 58.300 23.400 58.700 25.700 ;
        RECT 59.200 23.400 59.600 25.700 ;
        RECT 60.000 23.400 60.400 25.700 ;
        RECT 63.000 23.400 63.400 25.700 ;
        RECT 63.800 23.400 64.200 25.700 ;
        RECT 64.900 23.400 65.300 25.700 ;
        RECT 65.700 23.400 66.100 25.700 ;
        RECT 66.500 23.400 66.900 25.700 ;
        RECT 67.400 23.400 67.800 25.700 ;
        RECT 68.200 23.400 68.600 25.700 ;
        RECT 69.000 23.400 69.400 25.700 ;
        RECT 69.900 23.400 70.300 25.700 ;
        RECT 70.700 23.400 71.100 25.700 ;
        RECT 73.700 23.400 74.100 25.700 ;
        RECT 74.500 23.400 74.900 25.700 ;
        RECT 75.600 23.400 76.000 25.700 ;
        RECT 76.400 23.400 76.800 25.700 ;
        RECT 77.200 23.400 77.600 25.700 ;
        RECT 78.100 23.400 78.500 25.700 ;
        RECT 78.900 23.400 79.300 25.700 ;
        RECT 79.700 23.400 80.100 25.700 ;
        RECT 80.600 23.400 81.000 25.700 ;
        RECT 81.400 23.400 81.800 25.700 ;
        RECT 1.000 22.500 1.200 23.400 ;
        RECT 2.900 22.500 3.100 23.400 ;
        RECT 7.000 22.500 7.200 23.400 ;
        RECT 8.700 22.500 8.900 23.400 ;
        RECT 9.600 22.500 9.800 23.400 ;
        RECT 11.500 22.500 11.700 23.400 ;
        RECT 15.600 22.500 15.800 23.400 ;
        RECT 17.300 22.500 17.500 23.400 ;
        RECT 20.300 22.500 20.500 23.400 ;
        RECT 22.200 22.500 22.400 23.400 ;
        RECT 26.300 22.500 26.500 23.400 ;
        RECT 28.000 22.500 28.200 23.400 ;
        RECT 31.000 22.500 31.200 23.400 ;
        RECT 32.900 22.500 33.100 23.400 ;
        RECT 37.000 22.500 37.200 23.400 ;
        RECT 38.700 22.500 38.900 23.400 ;
        RECT 41.700 22.500 41.900 23.400 ;
        RECT 43.600 22.500 43.800 23.400 ;
        RECT 47.700 22.500 47.900 23.400 ;
        RECT 49.400 22.500 49.600 23.400 ;
        RECT 52.400 22.500 52.600 23.400 ;
        RECT 54.300 22.500 54.500 23.400 ;
        RECT 58.400 22.500 58.600 23.400 ;
        RECT 60.100 22.500 60.300 23.400 ;
        RECT 63.100 22.500 63.300 23.400 ;
        RECT 65.000 22.500 65.200 23.400 ;
        RECT 69.100 22.500 69.300 23.400 ;
        RECT 70.800 22.500 71.000 23.400 ;
        RECT 73.800 22.500 74.000 23.400 ;
        RECT 75.700 22.500 75.900 23.400 ;
        RECT 79.800 22.500 80.000 23.400 ;
        RECT 81.500 22.500 81.700 23.400 ;
        RECT 0.600 21.300 82.100 22.500 ;
        RECT 1.700 20.700 1.900 21.300 ;
        RECT 3.500 20.700 3.700 21.300 ;
        RECT 5.400 20.700 5.600 21.300 ;
        RECT 7.200 20.700 7.400 21.300 ;
        RECT 10.300 20.700 10.500 21.300 ;
        RECT 12.100 20.700 12.300 21.300 ;
        RECT 14.000 20.700 14.200 21.300 ;
        RECT 15.800 20.700 16.000 21.300 ;
        RECT 21.000 20.700 21.200 21.300 ;
        RECT 22.800 20.700 23.000 21.300 ;
        RECT 24.700 20.700 24.900 21.300 ;
        RECT 26.500 20.700 26.700 21.300 ;
        RECT 31.700 20.700 31.900 21.300 ;
        RECT 33.500 20.700 33.700 21.300 ;
        RECT 35.400 20.700 35.600 21.300 ;
        RECT 37.200 20.700 37.400 21.300 ;
        RECT 42.400 20.700 42.600 21.300 ;
        RECT 44.200 20.700 44.400 21.300 ;
        RECT 46.100 20.700 46.300 21.300 ;
        RECT 47.900 20.700 48.100 21.300 ;
        RECT 53.100 20.700 53.300 21.300 ;
        RECT 54.900 20.700 55.100 21.300 ;
        RECT 56.800 20.700 57.000 21.300 ;
        RECT 58.600 20.700 58.800 21.300 ;
        RECT 63.800 20.700 64.000 21.300 ;
        RECT 65.600 20.700 65.800 21.300 ;
        RECT 67.500 20.700 67.700 21.300 ;
        RECT 69.300 20.700 69.500 21.300 ;
        RECT 74.500 20.700 74.700 21.300 ;
        RECT 76.300 20.700 76.500 21.300 ;
        RECT 78.200 20.700 78.400 21.300 ;
        RECT 80.000 20.700 80.200 21.300 ;
        RECT 1.600 19.400 2.000 20.700 ;
        RECT 2.500 19.400 2.900 20.700 ;
        RECT 3.400 19.400 3.800 20.700 ;
        RECT 4.300 19.400 4.700 20.700 ;
        RECT 5.300 19.400 5.700 20.700 ;
        RECT 6.200 19.400 6.600 20.700 ;
        RECT 7.100 19.400 7.500 20.700 ;
        RECT 8.000 19.400 8.400 20.700 ;
        RECT 10.200 19.400 10.600 20.700 ;
        RECT 11.100 19.400 11.500 20.700 ;
        RECT 12.000 19.400 12.400 20.700 ;
        RECT 12.900 19.400 13.300 20.700 ;
        RECT 13.900 19.400 14.300 20.700 ;
        RECT 14.800 19.400 15.200 20.700 ;
        RECT 15.700 19.400 16.100 20.700 ;
        RECT 16.600 19.400 17.000 20.700 ;
        RECT 20.900 19.400 21.300 20.700 ;
        RECT 21.800 19.400 22.200 20.700 ;
        RECT 22.700 19.400 23.100 20.700 ;
        RECT 23.600 19.400 24.000 20.700 ;
        RECT 24.600 19.400 25.000 20.700 ;
        RECT 25.500 19.400 25.900 20.700 ;
        RECT 26.400 19.400 26.800 20.700 ;
        RECT 27.300 19.400 27.700 20.700 ;
        RECT 31.600 19.400 32.000 20.700 ;
        RECT 32.500 19.400 32.900 20.700 ;
        RECT 33.400 19.400 33.800 20.700 ;
        RECT 34.300 19.400 34.700 20.700 ;
        RECT 35.300 19.400 35.700 20.700 ;
        RECT 36.200 19.400 36.600 20.700 ;
        RECT 37.100 19.400 37.500 20.700 ;
        RECT 38.000 19.400 38.400 20.700 ;
        RECT 42.300 19.400 42.700 20.700 ;
        RECT 43.200 19.400 43.600 20.700 ;
        RECT 44.100 19.400 44.500 20.700 ;
        RECT 45.000 19.400 45.400 20.700 ;
        RECT 46.000 19.400 46.400 20.700 ;
        RECT 46.900 19.400 47.300 20.700 ;
        RECT 47.800 19.400 48.200 20.700 ;
        RECT 48.700 19.400 49.100 20.700 ;
        RECT 53.000 19.400 53.400 20.700 ;
        RECT 53.900 19.400 54.300 20.700 ;
        RECT 54.800 19.400 55.200 20.700 ;
        RECT 55.700 19.400 56.100 20.700 ;
        RECT 56.700 19.400 57.100 20.700 ;
        RECT 57.600 19.400 58.000 20.700 ;
        RECT 58.500 19.400 58.900 20.700 ;
        RECT 59.400 19.400 59.800 20.700 ;
        RECT 63.700 19.400 64.100 20.700 ;
        RECT 64.600 19.400 65.000 20.700 ;
        RECT 65.500 19.400 65.900 20.700 ;
        RECT 66.400 19.400 66.800 20.700 ;
        RECT 67.400 19.400 67.800 20.700 ;
        RECT 68.300 19.400 68.700 20.700 ;
        RECT 69.200 19.400 69.600 20.700 ;
        RECT 70.100 19.400 70.500 20.700 ;
        RECT 74.400 19.400 74.800 20.700 ;
        RECT 75.300 19.400 75.700 20.700 ;
        RECT 76.200 19.400 76.600 20.700 ;
        RECT 77.100 19.400 77.500 20.700 ;
        RECT 78.100 19.400 78.500 20.700 ;
        RECT 79.000 19.400 79.400 20.700 ;
        RECT 79.900 19.400 80.300 20.700 ;
        RECT 80.800 19.400 81.200 20.700 ;
        RECT 1.700 19.000 1.900 19.400 ;
        RECT 2.600 19.000 2.800 19.400 ;
        RECT 4.400 19.000 4.600 19.400 ;
        RECT 1.700 18.700 2.300 19.000 ;
        RECT 2.600 18.800 4.600 19.000 ;
        RECT 1.900 18.600 2.300 18.700 ;
        RECT 4.400 18.700 4.600 18.800 ;
        RECT 5.400 19.000 5.600 19.400 ;
        RECT 6.300 19.000 6.500 19.400 ;
        RECT 8.100 19.000 8.300 19.400 ;
        RECT 5.400 18.700 6.000 19.000 ;
        RECT 6.300 18.800 8.300 19.000 ;
        RECT 2.800 18.100 3.200 18.500 ;
        RECT 3.600 17.600 4.200 18.200 ;
        RECT 4.400 18.100 5.000 18.700 ;
        RECT 5.600 18.600 6.000 18.700 ;
        RECT 8.100 18.700 8.300 18.800 ;
        RECT 10.300 19.000 10.500 19.400 ;
        RECT 11.200 19.000 11.400 19.400 ;
        RECT 13.000 19.000 13.200 19.400 ;
        RECT 10.300 18.700 10.900 19.000 ;
        RECT 11.200 18.800 13.200 19.000 ;
        RECT 4.400 17.400 4.600 18.100 ;
        RECT 6.400 18.000 7.000 18.600 ;
        RECT 7.300 17.600 7.900 18.200 ;
        RECT 8.100 18.100 8.700 18.700 ;
        RECT 10.500 18.600 10.900 18.700 ;
        RECT 13.000 18.700 13.200 18.800 ;
        RECT 14.000 19.000 14.200 19.400 ;
        RECT 14.900 19.000 15.100 19.400 ;
        RECT 16.700 19.000 16.900 19.400 ;
        RECT 14.000 18.700 14.600 19.000 ;
        RECT 14.900 18.800 16.900 19.000 ;
        RECT 11.400 18.100 11.800 18.500 ;
        RECT 8.100 17.400 8.300 18.100 ;
        RECT 12.200 17.600 12.800 18.200 ;
        RECT 13.000 18.100 13.600 18.700 ;
        RECT 14.200 18.600 14.600 18.700 ;
        RECT 16.700 18.700 16.900 18.800 ;
        RECT 21.000 19.000 21.200 19.400 ;
        RECT 21.900 19.000 22.100 19.400 ;
        RECT 23.700 19.000 23.900 19.400 ;
        RECT 21.000 18.700 21.600 19.000 ;
        RECT 21.900 18.800 23.900 19.000 ;
        RECT 13.000 17.400 13.200 18.100 ;
        RECT 15.000 18.000 15.600 18.600 ;
        RECT 15.900 17.600 16.500 18.200 ;
        RECT 16.700 18.100 17.300 18.700 ;
        RECT 21.200 18.600 21.600 18.700 ;
        RECT 23.700 18.700 23.900 18.800 ;
        RECT 24.700 19.000 24.900 19.400 ;
        RECT 25.600 19.000 25.800 19.400 ;
        RECT 27.400 19.000 27.600 19.400 ;
        RECT 24.700 18.700 25.300 19.000 ;
        RECT 25.600 18.800 27.600 19.000 ;
        RECT 22.100 18.100 22.500 18.500 ;
        RECT 16.700 17.400 16.900 18.100 ;
        RECT 22.900 17.600 23.500 18.200 ;
        RECT 23.700 18.100 24.300 18.700 ;
        RECT 24.900 18.600 25.300 18.700 ;
        RECT 27.400 18.700 27.600 18.800 ;
        RECT 31.700 19.000 31.900 19.400 ;
        RECT 32.600 19.000 32.800 19.400 ;
        RECT 34.400 19.000 34.600 19.400 ;
        RECT 31.700 18.700 32.300 19.000 ;
        RECT 32.600 18.800 34.600 19.000 ;
        RECT 23.700 17.400 23.900 18.100 ;
        RECT 25.700 18.000 26.300 18.600 ;
        RECT 26.600 17.600 27.200 18.200 ;
        RECT 27.400 18.100 28.000 18.700 ;
        RECT 31.900 18.600 32.300 18.700 ;
        RECT 34.400 18.700 34.600 18.800 ;
        RECT 35.400 19.000 35.600 19.400 ;
        RECT 36.300 19.000 36.500 19.400 ;
        RECT 38.100 19.000 38.300 19.400 ;
        RECT 35.400 18.700 36.000 19.000 ;
        RECT 36.300 18.800 38.300 19.000 ;
        RECT 32.800 18.100 33.200 18.500 ;
        RECT 27.400 17.400 27.600 18.100 ;
        RECT 33.600 17.600 34.200 18.200 ;
        RECT 34.400 18.100 35.000 18.700 ;
        RECT 35.600 18.600 36.000 18.700 ;
        RECT 38.100 18.700 38.300 18.800 ;
        RECT 42.400 19.000 42.600 19.400 ;
        RECT 43.300 19.000 43.500 19.400 ;
        RECT 45.100 19.000 45.300 19.400 ;
        RECT 42.400 18.700 43.000 19.000 ;
        RECT 43.300 18.800 45.300 19.000 ;
        RECT 34.400 17.400 34.600 18.100 ;
        RECT 36.400 18.000 37.000 18.600 ;
        RECT 37.300 17.600 37.900 18.200 ;
        RECT 38.100 18.100 38.700 18.700 ;
        RECT 42.600 18.600 43.000 18.700 ;
        RECT 45.100 18.700 45.300 18.800 ;
        RECT 46.100 19.000 46.300 19.400 ;
        RECT 47.000 19.000 47.200 19.400 ;
        RECT 48.800 19.000 49.000 19.400 ;
        RECT 46.100 18.700 46.700 19.000 ;
        RECT 47.000 18.800 49.000 19.000 ;
        RECT 43.500 18.100 43.900 18.500 ;
        RECT 38.100 17.400 38.300 18.100 ;
        RECT 44.300 17.600 44.900 18.200 ;
        RECT 45.100 18.100 45.700 18.700 ;
        RECT 46.300 18.600 46.700 18.700 ;
        RECT 48.800 18.700 49.000 18.800 ;
        RECT 53.100 19.000 53.300 19.400 ;
        RECT 54.000 19.000 54.200 19.400 ;
        RECT 55.800 19.000 56.000 19.400 ;
        RECT 53.100 18.700 53.700 19.000 ;
        RECT 54.000 18.800 56.000 19.000 ;
        RECT 45.100 17.400 45.300 18.100 ;
        RECT 47.100 18.000 47.700 18.600 ;
        RECT 48.000 17.600 48.600 18.200 ;
        RECT 48.800 18.100 49.400 18.700 ;
        RECT 53.300 18.600 53.700 18.700 ;
        RECT 55.800 18.700 56.000 18.800 ;
        RECT 56.800 19.000 57.000 19.400 ;
        RECT 57.700 19.000 57.900 19.400 ;
        RECT 59.500 19.000 59.700 19.400 ;
        RECT 56.800 18.700 57.400 19.000 ;
        RECT 57.700 18.800 59.700 19.000 ;
        RECT 54.200 18.100 54.600 18.500 ;
        RECT 48.800 17.400 49.000 18.100 ;
        RECT 55.000 17.600 55.600 18.200 ;
        RECT 55.800 18.100 56.400 18.700 ;
        RECT 57.000 18.600 57.400 18.700 ;
        RECT 59.500 18.700 59.700 18.800 ;
        RECT 63.800 19.000 64.000 19.400 ;
        RECT 64.700 19.000 64.900 19.400 ;
        RECT 66.500 19.000 66.700 19.400 ;
        RECT 63.800 18.700 64.400 19.000 ;
        RECT 64.700 18.800 66.700 19.000 ;
        RECT 55.800 17.400 56.000 18.100 ;
        RECT 57.800 18.000 58.400 18.600 ;
        RECT 58.700 17.600 59.300 18.200 ;
        RECT 59.500 18.100 60.100 18.700 ;
        RECT 64.000 18.600 64.400 18.700 ;
        RECT 66.500 18.700 66.700 18.800 ;
        RECT 67.500 19.000 67.700 19.400 ;
        RECT 68.400 19.000 68.600 19.400 ;
        RECT 70.200 19.000 70.400 19.400 ;
        RECT 67.500 18.700 68.100 19.000 ;
        RECT 68.400 18.800 70.400 19.000 ;
        RECT 64.900 18.100 65.300 18.500 ;
        RECT 59.500 17.400 59.700 18.100 ;
        RECT 65.700 17.600 66.300 18.200 ;
        RECT 66.500 18.100 67.100 18.700 ;
        RECT 67.700 18.600 68.100 18.700 ;
        RECT 70.200 18.700 70.400 18.800 ;
        RECT 74.500 19.000 74.700 19.400 ;
        RECT 75.400 19.000 75.600 19.400 ;
        RECT 77.200 19.000 77.400 19.400 ;
        RECT 74.500 18.700 75.100 19.000 ;
        RECT 75.400 18.800 77.400 19.000 ;
        RECT 66.500 17.400 66.700 18.100 ;
        RECT 68.500 18.000 69.100 18.600 ;
        RECT 69.400 17.600 70.000 18.200 ;
        RECT 70.200 18.100 70.800 18.700 ;
        RECT 74.700 18.600 75.100 18.700 ;
        RECT 77.200 18.700 77.400 18.800 ;
        RECT 78.200 19.000 78.400 19.400 ;
        RECT 79.100 19.000 79.300 19.400 ;
        RECT 80.900 19.000 81.100 19.400 ;
        RECT 78.200 18.700 78.800 19.000 ;
        RECT 79.100 18.800 81.100 19.000 ;
        RECT 75.600 18.100 76.000 18.500 ;
        RECT 70.200 17.400 70.400 18.100 ;
        RECT 76.400 17.600 77.000 18.200 ;
        RECT 77.200 18.100 77.800 18.700 ;
        RECT 78.400 18.600 78.800 18.700 ;
        RECT 80.900 18.700 81.100 18.800 ;
        RECT 77.200 17.400 77.400 18.100 ;
        RECT 79.200 18.000 79.800 18.600 ;
        RECT 80.100 17.600 80.700 18.200 ;
        RECT 80.900 18.100 81.500 18.700 ;
        RECT 80.900 17.400 81.100 18.100 ;
        RECT 1.600 16.600 2.000 17.400 ;
        RECT 2.500 16.600 2.900 17.400 ;
        RECT 3.400 16.600 3.800 17.400 ;
        RECT 4.300 16.600 4.700 17.400 ;
        RECT 5.300 16.600 5.700 17.400 ;
        RECT 6.200 16.600 6.600 17.400 ;
        RECT 7.100 16.600 7.500 17.400 ;
        RECT 8.000 16.600 8.400 17.400 ;
        RECT 10.200 16.600 10.600 17.400 ;
        RECT 11.100 16.600 11.500 17.400 ;
        RECT 12.000 16.600 12.400 17.400 ;
        RECT 12.900 16.600 13.300 17.400 ;
        RECT 13.900 16.600 14.300 17.400 ;
        RECT 14.800 16.600 15.200 17.400 ;
        RECT 15.700 16.600 16.100 17.400 ;
        RECT 16.600 16.600 17.000 17.400 ;
        RECT 20.900 16.600 21.300 17.400 ;
        RECT 21.800 16.600 22.200 17.400 ;
        RECT 22.700 16.600 23.100 17.400 ;
        RECT 23.600 16.600 24.000 17.400 ;
        RECT 24.600 16.600 25.000 17.400 ;
        RECT 25.500 16.600 25.900 17.400 ;
        RECT 26.400 16.600 26.800 17.400 ;
        RECT 27.300 16.600 27.700 17.400 ;
        RECT 31.600 16.600 32.000 17.400 ;
        RECT 32.500 16.600 32.900 17.400 ;
        RECT 33.400 16.600 33.800 17.400 ;
        RECT 34.300 16.600 34.700 17.400 ;
        RECT 35.300 16.600 35.700 17.400 ;
        RECT 36.200 16.600 36.600 17.400 ;
        RECT 37.100 16.600 37.500 17.400 ;
        RECT 38.000 16.600 38.400 17.400 ;
        RECT 42.300 16.600 42.700 17.400 ;
        RECT 43.200 16.600 43.600 17.400 ;
        RECT 44.100 16.600 44.500 17.400 ;
        RECT 45.000 16.600 45.400 17.400 ;
        RECT 46.000 16.600 46.400 17.400 ;
        RECT 46.900 16.600 47.300 17.400 ;
        RECT 47.800 16.600 48.200 17.400 ;
        RECT 48.700 16.600 49.100 17.400 ;
        RECT 53.000 16.600 53.400 17.400 ;
        RECT 53.900 16.600 54.300 17.400 ;
        RECT 54.800 16.600 55.200 17.400 ;
        RECT 55.700 16.600 56.100 17.400 ;
        RECT 56.700 16.600 57.100 17.400 ;
        RECT 57.600 16.600 58.000 17.400 ;
        RECT 58.500 16.600 58.900 17.400 ;
        RECT 59.400 16.600 59.800 17.400 ;
        RECT 63.700 16.600 64.100 17.400 ;
        RECT 64.600 16.600 65.000 17.400 ;
        RECT 65.500 16.600 65.900 17.400 ;
        RECT 66.400 16.600 66.800 17.400 ;
        RECT 67.400 16.600 67.800 17.400 ;
        RECT 68.300 16.600 68.700 17.400 ;
        RECT 69.200 16.600 69.600 17.400 ;
        RECT 70.100 16.600 70.500 17.400 ;
        RECT 74.400 16.600 74.800 17.400 ;
        RECT 75.300 16.600 75.700 17.400 ;
        RECT 76.200 16.600 76.600 17.400 ;
        RECT 77.100 16.600 77.500 17.400 ;
        RECT 78.100 16.600 78.500 17.400 ;
        RECT 79.000 16.600 79.400 17.400 ;
        RECT 79.900 16.600 80.300 17.400 ;
        RECT 80.800 16.600 81.200 17.400 ;
        RECT 1.700 16.000 1.900 16.600 ;
        RECT 5.400 16.000 5.600 16.600 ;
        RECT 10.300 16.000 10.500 16.600 ;
        RECT 14.000 16.000 14.200 16.600 ;
        RECT 21.000 16.000 21.200 16.600 ;
        RECT 24.700 16.000 24.900 16.600 ;
        RECT 31.700 16.000 31.900 16.600 ;
        RECT 35.400 16.000 35.600 16.600 ;
        RECT 42.400 16.000 42.600 16.600 ;
        RECT 46.100 16.000 46.300 16.600 ;
        RECT 53.100 16.000 53.300 16.600 ;
        RECT 56.800 16.000 57.000 16.600 ;
        RECT 63.800 16.000 64.000 16.600 ;
        RECT 67.500 16.000 67.700 16.600 ;
        RECT 74.500 16.000 74.700 16.600 ;
        RECT 78.200 16.000 78.400 16.600 ;
        RECT 0.600 14.600 82.100 16.000 ;
        RECT 1.700 14.000 1.900 14.600 ;
        RECT 5.400 14.000 5.600 14.600 ;
        RECT 10.300 14.000 10.500 14.600 ;
        RECT 14.000 14.000 14.200 14.600 ;
        RECT 21.000 14.000 21.200 14.600 ;
        RECT 24.700 14.000 24.900 14.600 ;
        RECT 31.700 14.000 31.900 14.600 ;
        RECT 35.400 14.000 35.600 14.600 ;
        RECT 42.400 14.000 42.600 14.600 ;
        RECT 46.100 14.000 46.300 14.600 ;
        RECT 53.100 14.000 53.300 14.600 ;
        RECT 56.800 14.000 57.000 14.600 ;
        RECT 63.800 14.000 64.000 14.600 ;
        RECT 67.500 14.000 67.700 14.600 ;
        RECT 74.500 14.000 74.700 14.600 ;
        RECT 78.200 14.000 78.400 14.600 ;
        RECT 1.600 13.200 2.000 14.000 ;
        RECT 2.500 13.200 2.900 14.000 ;
        RECT 3.400 13.200 3.800 14.000 ;
        RECT 4.300 13.200 4.700 14.000 ;
        RECT 5.300 13.200 5.700 14.000 ;
        RECT 6.200 13.200 6.600 14.000 ;
        RECT 7.100 13.200 7.500 14.000 ;
        RECT 8.000 13.200 8.400 14.000 ;
        RECT 10.200 13.200 10.600 14.000 ;
        RECT 11.100 13.200 11.500 14.000 ;
        RECT 12.000 13.200 12.400 14.000 ;
        RECT 12.900 13.200 13.300 14.000 ;
        RECT 13.900 13.200 14.300 14.000 ;
        RECT 14.800 13.200 15.200 14.000 ;
        RECT 15.700 13.200 16.100 14.000 ;
        RECT 16.600 13.200 17.000 14.000 ;
        RECT 20.900 13.200 21.300 14.000 ;
        RECT 21.800 13.200 22.200 14.000 ;
        RECT 22.700 13.200 23.100 14.000 ;
        RECT 23.600 13.200 24.000 14.000 ;
        RECT 24.600 13.200 25.000 14.000 ;
        RECT 25.500 13.200 25.900 14.000 ;
        RECT 26.400 13.200 26.800 14.000 ;
        RECT 27.300 13.200 27.700 14.000 ;
        RECT 31.600 13.200 32.000 14.000 ;
        RECT 32.500 13.200 32.900 14.000 ;
        RECT 33.400 13.200 33.800 14.000 ;
        RECT 34.300 13.200 34.700 14.000 ;
        RECT 35.300 13.200 35.700 14.000 ;
        RECT 36.200 13.200 36.600 14.000 ;
        RECT 37.100 13.200 37.500 14.000 ;
        RECT 38.000 13.200 38.400 14.000 ;
        RECT 42.300 13.200 42.700 14.000 ;
        RECT 43.200 13.200 43.600 14.000 ;
        RECT 44.100 13.200 44.500 14.000 ;
        RECT 45.000 13.200 45.400 14.000 ;
        RECT 46.000 13.200 46.400 14.000 ;
        RECT 46.900 13.200 47.300 14.000 ;
        RECT 47.800 13.200 48.200 14.000 ;
        RECT 48.700 13.200 49.100 14.000 ;
        RECT 53.000 13.200 53.400 14.000 ;
        RECT 53.900 13.200 54.300 14.000 ;
        RECT 54.800 13.200 55.200 14.000 ;
        RECT 55.700 13.200 56.100 14.000 ;
        RECT 56.700 13.200 57.100 14.000 ;
        RECT 57.600 13.200 58.000 14.000 ;
        RECT 58.500 13.200 58.900 14.000 ;
        RECT 59.400 13.200 59.800 14.000 ;
        RECT 63.700 13.200 64.100 14.000 ;
        RECT 64.600 13.200 65.000 14.000 ;
        RECT 65.500 13.200 65.900 14.000 ;
        RECT 66.400 13.200 66.800 14.000 ;
        RECT 67.400 13.200 67.800 14.000 ;
        RECT 68.300 13.200 68.700 14.000 ;
        RECT 69.200 13.200 69.600 14.000 ;
        RECT 70.100 13.200 70.500 14.000 ;
        RECT 74.400 13.200 74.800 14.000 ;
        RECT 75.300 13.200 75.700 14.000 ;
        RECT 76.200 13.200 76.600 14.000 ;
        RECT 77.100 13.200 77.500 14.000 ;
        RECT 78.100 13.200 78.500 14.000 ;
        RECT 79.000 13.200 79.400 14.000 ;
        RECT 79.900 13.200 80.300 14.000 ;
        RECT 80.800 13.200 81.200 14.000 ;
        RECT 3.700 12.500 4.100 12.900 ;
        RECT 4.400 12.500 4.600 13.200 ;
        RECT 2.800 12.100 3.200 12.500 ;
        RECT 1.900 11.600 2.300 12.000 ;
        RECT 4.400 11.900 5.000 12.500 ;
        RECT 6.500 12.100 6.900 12.500 ;
        RECT 7.300 12.400 7.900 13.000 ;
        RECT 8.100 12.500 8.300 13.200 ;
        RECT 12.300 12.500 12.700 12.900 ;
        RECT 13.000 12.500 13.200 13.200 ;
        RECT 4.400 11.800 4.600 11.900 ;
        RECT 2.600 11.600 4.600 11.800 ;
        RECT 5.600 11.600 6.000 12.000 ;
        RECT 8.100 11.900 8.700 12.500 ;
        RECT 11.400 12.100 11.800 12.500 ;
        RECT 8.100 11.800 8.300 11.900 ;
        RECT 6.300 11.600 8.300 11.800 ;
        RECT 10.500 11.600 10.900 12.000 ;
        RECT 13.000 11.900 13.600 12.500 ;
        RECT 15.100 12.100 15.500 12.500 ;
        RECT 15.900 12.400 16.500 13.000 ;
        RECT 16.700 12.500 16.900 13.200 ;
        RECT 23.000 12.500 23.400 12.900 ;
        RECT 23.700 12.500 23.900 13.200 ;
        RECT 13.000 11.800 13.200 11.900 ;
        RECT 11.200 11.600 13.200 11.800 ;
        RECT 14.200 11.600 14.600 12.000 ;
        RECT 16.700 11.900 17.300 12.500 ;
        RECT 22.100 12.100 22.500 12.500 ;
        RECT 16.700 11.800 16.900 11.900 ;
        RECT 14.900 11.600 16.900 11.800 ;
        RECT 21.200 11.600 21.600 12.000 ;
        RECT 23.700 11.900 24.300 12.500 ;
        RECT 25.800 12.100 26.200 12.500 ;
        RECT 26.600 12.400 27.200 13.000 ;
        RECT 27.400 12.500 27.600 13.200 ;
        RECT 33.700 12.500 34.100 12.900 ;
        RECT 34.400 12.500 34.600 13.200 ;
        RECT 23.700 11.800 23.900 11.900 ;
        RECT 21.900 11.600 23.900 11.800 ;
        RECT 24.900 11.600 25.300 12.000 ;
        RECT 27.400 11.900 28.000 12.500 ;
        RECT 32.800 12.100 33.200 12.500 ;
        RECT 27.400 11.800 27.600 11.900 ;
        RECT 25.600 11.600 27.600 11.800 ;
        RECT 31.900 11.600 32.300 12.000 ;
        RECT 34.400 11.900 35.000 12.500 ;
        RECT 36.500 12.100 36.900 12.500 ;
        RECT 37.300 12.400 37.900 13.000 ;
        RECT 38.100 12.500 38.300 13.200 ;
        RECT 44.400 12.500 44.800 12.900 ;
        RECT 45.100 12.500 45.300 13.200 ;
        RECT 34.400 11.800 34.600 11.900 ;
        RECT 32.600 11.600 34.600 11.800 ;
        RECT 35.600 11.600 36.000 12.000 ;
        RECT 38.100 11.900 38.700 12.500 ;
        RECT 43.500 12.100 43.900 12.500 ;
        RECT 38.100 11.800 38.300 11.900 ;
        RECT 36.300 11.600 38.300 11.800 ;
        RECT 42.600 11.600 43.000 12.000 ;
        RECT 45.100 11.900 45.700 12.500 ;
        RECT 47.200 12.100 47.600 12.500 ;
        RECT 48.000 12.400 48.600 13.000 ;
        RECT 48.800 12.500 49.000 13.200 ;
        RECT 55.100 12.500 55.500 12.900 ;
        RECT 55.800 12.500 56.000 13.200 ;
        RECT 45.100 11.800 45.300 11.900 ;
        RECT 43.300 11.600 45.300 11.800 ;
        RECT 46.300 11.600 46.700 12.000 ;
        RECT 48.800 11.900 49.400 12.500 ;
        RECT 54.200 12.100 54.600 12.500 ;
        RECT 48.800 11.800 49.000 11.900 ;
        RECT 47.000 11.600 49.000 11.800 ;
        RECT 53.300 11.600 53.700 12.000 ;
        RECT 55.800 11.900 56.400 12.500 ;
        RECT 57.900 12.100 58.300 12.500 ;
        RECT 58.700 12.400 59.300 13.000 ;
        RECT 59.500 12.500 59.700 13.200 ;
        RECT 65.800 12.500 66.200 12.900 ;
        RECT 66.500 12.500 66.700 13.200 ;
        RECT 55.800 11.800 56.000 11.900 ;
        RECT 54.000 11.600 56.000 11.800 ;
        RECT 57.000 11.600 57.400 12.000 ;
        RECT 59.500 11.900 60.100 12.500 ;
        RECT 64.900 12.100 65.300 12.500 ;
        RECT 59.500 11.800 59.700 11.900 ;
        RECT 57.700 11.600 59.700 11.800 ;
        RECT 64.000 11.600 64.400 12.000 ;
        RECT 66.500 11.900 67.100 12.500 ;
        RECT 68.600 12.100 69.000 12.500 ;
        RECT 69.400 12.400 70.000 13.000 ;
        RECT 70.200 12.500 70.400 13.200 ;
        RECT 76.500 12.500 76.900 12.900 ;
        RECT 77.200 12.500 77.400 13.200 ;
        RECT 66.500 11.800 66.700 11.900 ;
        RECT 64.700 11.600 66.700 11.800 ;
        RECT 67.700 11.600 68.100 12.000 ;
        RECT 70.200 11.900 70.800 12.500 ;
        RECT 75.600 12.100 76.000 12.500 ;
        RECT 70.200 11.800 70.400 11.900 ;
        RECT 68.400 11.600 70.400 11.800 ;
        RECT 74.700 11.600 75.100 12.000 ;
        RECT 77.200 11.900 77.800 12.500 ;
        RECT 79.300 12.100 79.700 12.500 ;
        RECT 80.100 12.400 80.700 13.000 ;
        RECT 80.900 12.500 81.100 13.200 ;
        RECT 77.200 11.800 77.400 11.900 ;
        RECT 75.400 11.600 77.400 11.800 ;
        RECT 78.400 11.600 78.800 12.000 ;
        RECT 80.900 11.900 81.500 12.500 ;
        RECT 80.900 11.800 81.100 11.900 ;
        RECT 79.100 11.600 81.100 11.800 ;
        RECT 2.600 11.200 2.800 11.600 ;
        RECT 4.400 11.200 4.600 11.600 ;
        RECT 6.300 11.200 6.500 11.600 ;
        RECT 8.100 11.200 8.300 11.600 ;
        RECT 11.200 11.200 11.400 11.600 ;
        RECT 13.000 11.200 13.200 11.600 ;
        RECT 14.900 11.200 15.100 11.600 ;
        RECT 16.700 11.200 16.900 11.600 ;
        RECT 21.900 11.200 22.100 11.600 ;
        RECT 23.700 11.200 23.900 11.600 ;
        RECT 25.600 11.200 25.800 11.600 ;
        RECT 27.400 11.200 27.600 11.600 ;
        RECT 32.600 11.200 32.800 11.600 ;
        RECT 34.400 11.200 34.600 11.600 ;
        RECT 36.300 11.200 36.500 11.600 ;
        RECT 38.100 11.200 38.300 11.600 ;
        RECT 43.300 11.200 43.500 11.600 ;
        RECT 45.100 11.200 45.300 11.600 ;
        RECT 47.000 11.200 47.200 11.600 ;
        RECT 48.800 11.200 49.000 11.600 ;
        RECT 54.000 11.200 54.200 11.600 ;
        RECT 55.800 11.200 56.000 11.600 ;
        RECT 57.700 11.200 57.900 11.600 ;
        RECT 59.500 11.200 59.700 11.600 ;
        RECT 64.700 11.200 64.900 11.600 ;
        RECT 66.500 11.200 66.700 11.600 ;
        RECT 68.400 11.200 68.600 11.600 ;
        RECT 70.200 11.200 70.400 11.600 ;
        RECT 75.400 11.200 75.600 11.600 ;
        RECT 77.200 11.200 77.400 11.600 ;
        RECT 79.100 11.200 79.300 11.600 ;
        RECT 80.900 11.200 81.100 11.600 ;
        RECT 1.600 9.900 2.000 11.200 ;
        RECT 2.500 9.900 2.900 11.200 ;
        RECT 3.400 9.900 3.800 11.200 ;
        RECT 4.300 9.900 4.700 11.200 ;
        RECT 5.300 9.900 5.700 11.200 ;
        RECT 6.200 9.900 6.600 11.200 ;
        RECT 7.100 9.900 7.500 11.200 ;
        RECT 8.000 9.900 8.400 11.200 ;
        RECT 10.200 9.900 10.600 11.200 ;
        RECT 11.100 9.900 11.500 11.200 ;
        RECT 12.000 9.900 12.400 11.200 ;
        RECT 12.900 9.900 13.300 11.200 ;
        RECT 13.900 9.900 14.300 11.200 ;
        RECT 14.800 9.900 15.200 11.200 ;
        RECT 15.700 9.900 16.100 11.200 ;
        RECT 16.600 9.900 17.000 11.200 ;
        RECT 20.900 9.900 21.300 11.200 ;
        RECT 21.800 9.900 22.200 11.200 ;
        RECT 22.700 9.900 23.100 11.200 ;
        RECT 23.600 9.900 24.000 11.200 ;
        RECT 24.600 9.900 25.000 11.200 ;
        RECT 25.500 9.900 25.900 11.200 ;
        RECT 26.400 9.900 26.800 11.200 ;
        RECT 27.300 9.900 27.700 11.200 ;
        RECT 31.600 9.900 32.000 11.200 ;
        RECT 32.500 9.900 32.900 11.200 ;
        RECT 33.400 9.900 33.800 11.200 ;
        RECT 34.300 9.900 34.700 11.200 ;
        RECT 35.300 9.900 35.700 11.200 ;
        RECT 36.200 9.900 36.600 11.200 ;
        RECT 37.100 9.900 37.500 11.200 ;
        RECT 38.000 9.900 38.400 11.200 ;
        RECT 42.300 9.900 42.700 11.200 ;
        RECT 43.200 9.900 43.600 11.200 ;
        RECT 44.100 9.900 44.500 11.200 ;
        RECT 45.000 9.900 45.400 11.200 ;
        RECT 46.000 9.900 46.400 11.200 ;
        RECT 46.900 9.900 47.300 11.200 ;
        RECT 47.800 9.900 48.200 11.200 ;
        RECT 48.700 9.900 49.100 11.200 ;
        RECT 53.000 9.900 53.400 11.200 ;
        RECT 53.900 9.900 54.300 11.200 ;
        RECT 54.800 9.900 55.200 11.200 ;
        RECT 55.700 9.900 56.100 11.200 ;
        RECT 56.700 9.900 57.100 11.200 ;
        RECT 57.600 9.900 58.000 11.200 ;
        RECT 58.500 9.900 58.900 11.200 ;
        RECT 59.400 9.900 59.800 11.200 ;
        RECT 63.700 9.900 64.100 11.200 ;
        RECT 64.600 9.900 65.000 11.200 ;
        RECT 65.500 9.900 65.900 11.200 ;
        RECT 66.400 9.900 66.800 11.200 ;
        RECT 67.400 9.900 67.800 11.200 ;
        RECT 68.300 9.900 68.700 11.200 ;
        RECT 69.200 9.900 69.600 11.200 ;
        RECT 70.100 9.900 70.500 11.200 ;
        RECT 74.400 9.900 74.800 11.200 ;
        RECT 75.300 9.900 75.700 11.200 ;
        RECT 76.200 9.900 76.600 11.200 ;
        RECT 77.100 9.900 77.500 11.200 ;
        RECT 78.100 9.900 78.500 11.200 ;
        RECT 79.000 9.900 79.400 11.200 ;
        RECT 79.900 9.900 80.300 11.200 ;
        RECT 80.800 9.900 81.200 11.200 ;
        RECT 1.700 9.300 1.900 9.900 ;
        RECT 3.500 9.300 3.700 9.900 ;
        RECT 5.400 9.300 5.600 9.900 ;
        RECT 7.200 9.300 7.400 9.900 ;
        RECT 10.300 9.300 10.500 9.900 ;
        RECT 12.100 9.300 12.300 9.900 ;
        RECT 14.000 9.300 14.200 9.900 ;
        RECT 15.800 9.300 16.000 9.900 ;
        RECT 21.000 9.300 21.200 9.900 ;
        RECT 22.800 9.300 23.000 9.900 ;
        RECT 24.700 9.300 24.900 9.900 ;
        RECT 26.500 9.300 26.700 9.900 ;
        RECT 31.700 9.300 31.900 9.900 ;
        RECT 33.500 9.300 33.700 9.900 ;
        RECT 35.400 9.300 35.600 9.900 ;
        RECT 37.200 9.300 37.400 9.900 ;
        RECT 42.400 9.300 42.600 9.900 ;
        RECT 44.200 9.300 44.400 9.900 ;
        RECT 46.100 9.300 46.300 9.900 ;
        RECT 47.900 9.300 48.100 9.900 ;
        RECT 53.100 9.300 53.300 9.900 ;
        RECT 54.900 9.300 55.100 9.900 ;
        RECT 56.800 9.300 57.000 9.900 ;
        RECT 58.600 9.300 58.800 9.900 ;
        RECT 63.800 9.300 64.000 9.900 ;
        RECT 65.600 9.300 65.800 9.900 ;
        RECT 67.500 9.300 67.700 9.900 ;
        RECT 69.300 9.300 69.500 9.900 ;
        RECT 74.500 9.300 74.700 9.900 ;
        RECT 76.300 9.300 76.500 9.900 ;
        RECT 78.200 9.300 78.400 9.900 ;
        RECT 80.000 9.300 80.200 9.900 ;
        RECT 1.100 8.100 81.500 9.300 ;
        RECT 1.700 7.500 1.900 8.100 ;
        RECT 3.500 7.500 3.700 8.100 ;
        RECT 5.400 7.500 5.600 8.100 ;
        RECT 7.200 7.500 7.400 8.100 ;
        RECT 10.300 7.500 10.500 8.100 ;
        RECT 12.100 7.500 12.300 8.100 ;
        RECT 14.000 7.500 14.200 8.100 ;
        RECT 15.800 7.500 16.000 8.100 ;
        RECT 21.000 7.500 21.200 8.100 ;
        RECT 22.800 7.500 23.000 8.100 ;
        RECT 24.700 7.500 24.900 8.100 ;
        RECT 26.500 7.500 26.700 8.100 ;
        RECT 31.700 7.500 31.900 8.100 ;
        RECT 33.500 7.500 33.700 8.100 ;
        RECT 35.400 7.500 35.600 8.100 ;
        RECT 37.200 7.500 37.400 8.100 ;
        RECT 42.400 7.500 42.600 8.100 ;
        RECT 44.200 7.500 44.400 8.100 ;
        RECT 46.100 7.500 46.300 8.100 ;
        RECT 47.900 7.500 48.100 8.100 ;
        RECT 53.100 7.500 53.300 8.100 ;
        RECT 54.900 7.500 55.100 8.100 ;
        RECT 56.800 7.500 57.000 8.100 ;
        RECT 58.600 7.500 58.800 8.100 ;
        RECT 63.800 7.500 64.000 8.100 ;
        RECT 65.600 7.500 65.800 8.100 ;
        RECT 67.500 7.500 67.700 8.100 ;
        RECT 69.300 7.500 69.500 8.100 ;
        RECT 74.500 7.500 74.700 8.100 ;
        RECT 76.300 7.500 76.500 8.100 ;
        RECT 78.200 7.500 78.400 8.100 ;
        RECT 80.000 7.500 80.200 8.100 ;
        RECT 1.600 6.200 2.000 7.500 ;
        RECT 2.500 6.200 2.900 7.500 ;
        RECT 3.400 6.200 3.800 7.500 ;
        RECT 4.300 6.200 4.700 7.500 ;
        RECT 5.300 6.200 5.700 7.500 ;
        RECT 6.200 6.200 6.600 7.500 ;
        RECT 7.100 6.200 7.500 7.500 ;
        RECT 8.000 6.200 8.400 7.500 ;
        RECT 10.200 6.200 10.600 7.500 ;
        RECT 11.100 6.200 11.500 7.500 ;
        RECT 12.000 6.200 12.400 7.500 ;
        RECT 12.900 6.200 13.300 7.500 ;
        RECT 13.900 6.200 14.300 7.500 ;
        RECT 14.800 6.200 15.200 7.500 ;
        RECT 15.700 6.200 16.100 7.500 ;
        RECT 16.600 6.200 17.000 7.500 ;
        RECT 20.900 6.200 21.300 7.500 ;
        RECT 21.800 6.200 22.200 7.500 ;
        RECT 22.700 6.200 23.100 7.500 ;
        RECT 23.600 6.200 24.000 7.500 ;
        RECT 24.600 6.200 25.000 7.500 ;
        RECT 25.500 6.200 25.900 7.500 ;
        RECT 26.400 6.200 26.800 7.500 ;
        RECT 27.300 6.200 27.700 7.500 ;
        RECT 31.600 6.200 32.000 7.500 ;
        RECT 32.500 6.200 32.900 7.500 ;
        RECT 33.400 6.200 33.800 7.500 ;
        RECT 34.300 6.200 34.700 7.500 ;
        RECT 35.300 6.200 35.700 7.500 ;
        RECT 36.200 6.200 36.600 7.500 ;
        RECT 37.100 6.200 37.500 7.500 ;
        RECT 38.000 6.200 38.400 7.500 ;
        RECT 42.300 6.200 42.700 7.500 ;
        RECT 43.200 6.200 43.600 7.500 ;
        RECT 44.100 6.200 44.500 7.500 ;
        RECT 45.000 6.200 45.400 7.500 ;
        RECT 46.000 6.200 46.400 7.500 ;
        RECT 46.900 6.200 47.300 7.500 ;
        RECT 47.800 6.200 48.200 7.500 ;
        RECT 48.700 6.200 49.100 7.500 ;
        RECT 53.000 6.200 53.400 7.500 ;
        RECT 53.900 6.200 54.300 7.500 ;
        RECT 54.800 6.200 55.200 7.500 ;
        RECT 55.700 6.200 56.100 7.500 ;
        RECT 56.700 6.200 57.100 7.500 ;
        RECT 57.600 6.200 58.000 7.500 ;
        RECT 58.500 6.200 58.900 7.500 ;
        RECT 59.400 6.200 59.800 7.500 ;
        RECT 63.700 6.200 64.100 7.500 ;
        RECT 64.600 6.200 65.000 7.500 ;
        RECT 65.500 6.200 65.900 7.500 ;
        RECT 66.400 6.200 66.800 7.500 ;
        RECT 67.400 6.200 67.800 7.500 ;
        RECT 68.300 6.200 68.700 7.500 ;
        RECT 69.200 6.200 69.600 7.500 ;
        RECT 70.100 6.200 70.500 7.500 ;
        RECT 74.400 6.200 74.800 7.500 ;
        RECT 75.300 6.200 75.700 7.500 ;
        RECT 76.200 6.200 76.600 7.500 ;
        RECT 77.100 6.200 77.500 7.500 ;
        RECT 78.100 6.200 78.500 7.500 ;
        RECT 79.000 6.200 79.400 7.500 ;
        RECT 79.900 6.200 80.300 7.500 ;
        RECT 80.800 6.200 81.200 7.500 ;
        RECT 1.800 5.300 2.400 5.900 ;
        RECT 2.600 5.800 2.800 6.200 ;
        RECT 4.400 5.800 4.600 6.200 ;
        RECT 6.300 5.800 6.500 6.200 ;
        RECT 8.100 5.800 8.300 6.200 ;
        RECT 2.600 5.600 4.600 5.800 ;
        RECT 4.400 5.500 4.600 5.600 ;
        RECT 2.700 4.800 3.300 5.400 ;
        RECT 4.400 4.900 5.000 5.500 ;
        RECT 5.600 5.400 6.000 5.800 ;
        RECT 6.300 5.600 8.300 5.800 ;
        RECT 8.100 5.500 8.300 5.600 ;
        RECT 3.700 4.500 4.100 4.900 ;
        RECT 4.400 4.200 4.600 4.900 ;
        RECT 6.400 4.800 7.000 5.400 ;
        RECT 8.100 4.900 8.700 5.500 ;
        RECT 10.400 5.300 11.000 5.900 ;
        RECT 11.200 5.800 11.400 6.200 ;
        RECT 13.000 5.800 13.200 6.200 ;
        RECT 14.900 5.800 15.100 6.200 ;
        RECT 16.700 5.800 16.900 6.200 ;
        RECT 11.200 5.600 13.200 5.800 ;
        RECT 13.000 5.500 13.200 5.600 ;
        RECT 7.400 4.500 7.800 4.900 ;
        RECT 8.100 4.200 8.300 4.900 ;
        RECT 11.300 4.800 11.900 5.400 ;
        RECT 13.000 4.900 13.600 5.500 ;
        RECT 14.200 5.400 14.600 5.800 ;
        RECT 14.900 5.600 16.900 5.800 ;
        RECT 16.700 5.500 16.900 5.600 ;
        RECT 12.300 4.500 12.700 4.900 ;
        RECT 13.000 4.200 13.200 4.900 ;
        RECT 15.000 4.800 15.600 5.400 ;
        RECT 16.700 4.900 17.300 5.500 ;
        RECT 21.100 5.300 21.700 5.900 ;
        RECT 21.900 5.800 22.100 6.200 ;
        RECT 23.700 5.800 23.900 6.200 ;
        RECT 25.600 5.800 25.800 6.200 ;
        RECT 27.400 5.800 27.600 6.200 ;
        RECT 21.900 5.600 23.900 5.800 ;
        RECT 23.700 5.500 23.900 5.600 ;
        RECT 16.000 4.500 16.400 4.900 ;
        RECT 16.700 4.200 16.900 4.900 ;
        RECT 22.000 4.800 22.600 5.400 ;
        RECT 23.700 4.900 24.300 5.500 ;
        RECT 24.900 5.400 25.300 5.800 ;
        RECT 25.600 5.600 27.600 5.800 ;
        RECT 27.400 5.500 27.600 5.600 ;
        RECT 23.000 4.500 23.400 4.900 ;
        RECT 23.700 4.200 23.900 4.900 ;
        RECT 25.700 4.800 26.300 5.400 ;
        RECT 27.400 4.900 28.000 5.500 ;
        RECT 31.800 5.300 32.400 5.900 ;
        RECT 32.600 5.800 32.800 6.200 ;
        RECT 34.400 5.800 34.600 6.200 ;
        RECT 36.300 5.800 36.500 6.200 ;
        RECT 38.100 5.800 38.300 6.200 ;
        RECT 32.600 5.600 34.600 5.800 ;
        RECT 34.400 5.500 34.600 5.600 ;
        RECT 26.700 4.500 27.100 4.900 ;
        RECT 27.400 4.200 27.600 4.900 ;
        RECT 32.700 4.800 33.300 5.400 ;
        RECT 34.400 4.900 35.000 5.500 ;
        RECT 35.600 5.400 36.000 5.800 ;
        RECT 36.300 5.600 38.300 5.800 ;
        RECT 38.100 5.500 38.300 5.600 ;
        RECT 33.700 4.500 34.100 4.900 ;
        RECT 34.400 4.200 34.600 4.900 ;
        RECT 36.400 4.800 37.000 5.400 ;
        RECT 38.100 4.900 38.700 5.500 ;
        RECT 42.500 5.300 43.100 5.900 ;
        RECT 43.300 5.800 43.500 6.200 ;
        RECT 45.100 5.800 45.300 6.200 ;
        RECT 47.000 5.800 47.200 6.200 ;
        RECT 48.800 5.800 49.000 6.200 ;
        RECT 43.300 5.600 45.300 5.800 ;
        RECT 45.100 5.500 45.300 5.600 ;
        RECT 37.400 4.500 37.800 4.900 ;
        RECT 38.100 4.200 38.300 4.900 ;
        RECT 43.400 4.800 44.000 5.400 ;
        RECT 45.100 4.900 45.700 5.500 ;
        RECT 46.300 5.400 46.700 5.800 ;
        RECT 47.000 5.600 49.000 5.800 ;
        RECT 48.800 5.500 49.000 5.600 ;
        RECT 44.400 4.500 44.800 4.900 ;
        RECT 45.100 4.200 45.300 4.900 ;
        RECT 47.100 4.800 47.700 5.400 ;
        RECT 48.800 4.900 49.400 5.500 ;
        RECT 53.200 5.300 53.800 5.900 ;
        RECT 54.000 5.800 54.200 6.200 ;
        RECT 55.800 5.800 56.000 6.200 ;
        RECT 57.700 5.800 57.900 6.200 ;
        RECT 59.500 5.800 59.700 6.200 ;
        RECT 54.000 5.600 56.000 5.800 ;
        RECT 55.800 5.500 56.000 5.600 ;
        RECT 48.100 4.500 48.500 4.900 ;
        RECT 48.800 4.200 49.000 4.900 ;
        RECT 54.100 4.800 54.700 5.400 ;
        RECT 55.800 4.900 56.400 5.500 ;
        RECT 57.000 5.400 57.400 5.800 ;
        RECT 57.700 5.600 59.700 5.800 ;
        RECT 59.500 5.500 59.700 5.600 ;
        RECT 55.100 4.500 55.500 4.900 ;
        RECT 55.800 4.200 56.000 4.900 ;
        RECT 57.800 4.800 58.400 5.400 ;
        RECT 59.500 4.900 60.100 5.500 ;
        RECT 63.900 5.300 64.500 5.900 ;
        RECT 64.700 5.800 64.900 6.200 ;
        RECT 66.500 5.800 66.700 6.200 ;
        RECT 68.400 5.800 68.600 6.200 ;
        RECT 70.200 5.800 70.400 6.200 ;
        RECT 64.700 5.600 66.700 5.800 ;
        RECT 66.500 5.500 66.700 5.600 ;
        RECT 58.800 4.500 59.200 4.900 ;
        RECT 59.500 4.200 59.700 4.900 ;
        RECT 64.800 4.800 65.400 5.400 ;
        RECT 66.500 4.900 67.100 5.500 ;
        RECT 67.700 5.400 68.100 5.800 ;
        RECT 68.400 5.600 70.400 5.800 ;
        RECT 70.200 5.500 70.400 5.600 ;
        RECT 65.800 4.500 66.200 4.900 ;
        RECT 66.500 4.200 66.700 4.900 ;
        RECT 68.500 4.800 69.100 5.400 ;
        RECT 70.200 4.900 70.800 5.500 ;
        RECT 74.600 5.300 75.200 5.900 ;
        RECT 75.400 5.800 75.600 6.200 ;
        RECT 77.200 5.800 77.400 6.200 ;
        RECT 79.100 5.800 79.300 6.200 ;
        RECT 80.900 5.800 81.100 6.200 ;
        RECT 75.400 5.600 77.400 5.800 ;
        RECT 77.200 5.500 77.400 5.600 ;
        RECT 69.500 4.500 69.900 4.900 ;
        RECT 70.200 4.200 70.400 4.900 ;
        RECT 75.500 4.800 76.100 5.400 ;
        RECT 77.200 4.900 77.800 5.500 ;
        RECT 78.400 5.400 78.800 5.800 ;
        RECT 79.100 5.600 81.100 5.800 ;
        RECT 80.900 5.500 81.100 5.600 ;
        RECT 76.500 4.500 76.900 4.900 ;
        RECT 77.200 4.200 77.400 4.900 ;
        RECT 79.200 4.800 79.800 5.400 ;
        RECT 80.900 4.900 81.500 5.500 ;
        RECT 80.200 4.500 80.600 4.900 ;
        RECT 80.900 4.200 81.100 4.900 ;
        RECT 1.600 3.400 2.000 4.200 ;
        RECT 2.500 3.400 2.900 4.200 ;
        RECT 3.400 3.400 3.800 4.200 ;
        RECT 4.300 3.400 4.700 4.200 ;
        RECT 5.300 3.400 5.700 4.200 ;
        RECT 6.200 3.400 6.600 4.200 ;
        RECT 7.100 3.400 7.500 4.200 ;
        RECT 8.000 3.400 8.400 4.200 ;
        RECT 10.200 3.400 10.600 4.200 ;
        RECT 11.100 3.400 11.500 4.200 ;
        RECT 12.000 3.400 12.400 4.200 ;
        RECT 12.900 3.400 13.300 4.200 ;
        RECT 13.900 3.400 14.300 4.200 ;
        RECT 14.800 3.400 15.200 4.200 ;
        RECT 15.700 3.400 16.100 4.200 ;
        RECT 16.600 3.400 17.000 4.200 ;
        RECT 20.900 3.400 21.300 4.200 ;
        RECT 21.800 3.400 22.200 4.200 ;
        RECT 22.700 3.400 23.100 4.200 ;
        RECT 23.600 3.400 24.000 4.200 ;
        RECT 24.600 3.400 25.000 4.200 ;
        RECT 25.500 3.400 25.900 4.200 ;
        RECT 26.400 3.400 26.800 4.200 ;
        RECT 27.300 3.400 27.700 4.200 ;
        RECT 31.600 3.400 32.000 4.200 ;
        RECT 32.500 3.400 32.900 4.200 ;
        RECT 33.400 3.400 33.800 4.200 ;
        RECT 34.300 3.400 34.700 4.200 ;
        RECT 35.300 3.400 35.700 4.200 ;
        RECT 36.200 3.400 36.600 4.200 ;
        RECT 37.100 3.400 37.500 4.200 ;
        RECT 38.000 3.400 38.400 4.200 ;
        RECT 42.300 3.400 42.700 4.200 ;
        RECT 43.200 3.400 43.600 4.200 ;
        RECT 44.100 3.400 44.500 4.200 ;
        RECT 45.000 3.400 45.400 4.200 ;
        RECT 46.000 3.400 46.400 4.200 ;
        RECT 46.900 3.400 47.300 4.200 ;
        RECT 47.800 3.400 48.200 4.200 ;
        RECT 48.700 3.400 49.100 4.200 ;
        RECT 53.000 3.400 53.400 4.200 ;
        RECT 53.900 3.400 54.300 4.200 ;
        RECT 54.800 3.400 55.200 4.200 ;
        RECT 55.700 3.400 56.100 4.200 ;
        RECT 56.700 3.400 57.100 4.200 ;
        RECT 57.600 3.400 58.000 4.200 ;
        RECT 58.500 3.400 58.900 4.200 ;
        RECT 59.400 3.400 59.800 4.200 ;
        RECT 63.700 3.400 64.100 4.200 ;
        RECT 64.600 3.400 65.000 4.200 ;
        RECT 65.500 3.400 65.900 4.200 ;
        RECT 66.400 3.400 66.800 4.200 ;
        RECT 67.400 3.400 67.800 4.200 ;
        RECT 68.300 3.400 68.700 4.200 ;
        RECT 69.200 3.400 69.600 4.200 ;
        RECT 70.100 3.400 70.500 4.200 ;
        RECT 74.400 3.400 74.800 4.200 ;
        RECT 75.300 3.400 75.700 4.200 ;
        RECT 76.200 3.400 76.600 4.200 ;
        RECT 77.100 3.400 77.500 4.200 ;
        RECT 78.100 3.400 78.500 4.200 ;
        RECT 79.000 3.400 79.400 4.200 ;
        RECT 79.900 3.400 80.300 4.200 ;
        RECT 80.800 3.400 81.200 4.200 ;
        RECT 1.700 2.800 1.900 3.400 ;
        RECT 5.400 2.800 5.600 3.400 ;
        RECT 10.300 2.800 10.500 3.400 ;
        RECT 14.000 2.800 14.200 3.400 ;
        RECT 21.000 2.800 21.200 3.400 ;
        RECT 24.700 2.800 24.900 3.400 ;
        RECT 31.700 2.800 31.900 3.400 ;
        RECT 35.400 2.800 35.600 3.400 ;
        RECT 42.400 2.800 42.600 3.400 ;
        RECT 46.100 2.800 46.300 3.400 ;
        RECT 53.100 2.800 53.300 3.400 ;
        RECT 56.800 2.800 57.000 3.400 ;
        RECT 63.800 2.800 64.000 3.400 ;
        RECT 67.500 2.800 67.700 3.400 ;
        RECT 74.500 2.800 74.700 3.400 ;
        RECT 78.200 2.800 78.400 3.400 ;
        RECT 1.100 1.600 81.500 2.800 ;
        RECT 61.750 -28.300 77.550 -27.200 ;
        RECT 13.050 -31.950 23.250 -30.500 ;
        RECT 13.700 -32.650 14.500 -31.950 ;
        RECT 15.800 -32.650 16.600 -31.950 ;
        RECT 17.800 -32.650 18.600 -31.950 ;
        RECT 19.800 -32.650 20.600 -31.950 ;
        RECT 22.000 -32.650 22.800 -31.950 ;
        RECT 29.800 -32.150 31.000 -30.850 ;
        RECT 35.650 -32.450 36.850 -31.150 ;
        RECT 41.450 -32.250 42.650 -30.950 ;
        RECT 61.750 -32.950 63.150 -28.300 ;
        RECT 66.750 -29.600 67.150 -29.200 ;
        RECT 67.350 -29.900 67.650 -28.300 ;
        RECT 23.100 -33.950 23.800 -33.250 ;
        RECT 53.850 -33.500 63.150 -32.950 ;
        RECT 22.000 -35.250 22.800 -34.850 ;
        RECT 53.850 -35.100 54.250 -33.500 ;
        RECT 20.800 -36.250 21.500 -35.550 ;
        RECT 19.800 -36.750 20.600 -36.350 ;
        RECT 18.800 -38.250 19.500 -37.550 ;
        RECT 17.800 -39.750 18.600 -39.350 ;
        RECT 5.150 -40.800 7.200 -40.100 ;
        RECT 2.600 -48.200 3.800 -46.900 ;
        RECT 2.650 -52.100 3.850 -50.800 ;
        RECT 4.900 -54.150 5.300 -41.600 ;
        RECT 3.900 -55.400 5.300 -54.150 ;
        RECT 1.950 -58.750 3.150 -57.450 ;
        RECT 2.100 -61.850 3.300 -60.550 ;
        RECT 2.350 -65.200 3.550 -63.900 ;
        RECT 4.900 -65.700 5.300 -55.400 ;
        RECT 5.700 -54.600 6.100 -41.600 ;
        RECT 6.750 -46.000 7.200 -40.800 ;
        RECT 16.700 -40.950 17.400 -40.250 ;
        RECT 18.100 -40.350 18.600 -39.750 ;
        RECT 19.900 -40.050 20.500 -36.750 ;
        RECT 18.100 -40.750 19.250 -40.350 ;
        RECT 19.900 -40.750 20.950 -40.050 ;
        RECT 8.550 -42.500 10.100 -41.500 ;
        RECT 8.650 -46.000 9.050 -43.250 ;
        RECT 9.450 -45.550 9.850 -42.500 ;
        RECT 11.400 -42.800 12.600 -41.500 ;
        RECT 18.750 -41.800 19.250 -40.750 ;
        RECT 20.350 -41.800 20.950 -40.750 ;
        RECT 22.100 -41.300 22.700 -35.250 ;
        RECT 53.900 -35.950 54.450 -35.400 ;
        RECT 54.650 -35.450 55.050 -34.200 ;
        RECT 57.150 -34.550 57.600 -34.100 ;
        RECT 57.900 -34.300 63.150 -33.500 ;
        RECT 57.900 -34.350 61.300 -34.300 ;
        RECT 54.650 -35.950 55.400 -35.450 ;
        RECT 51.450 -36.300 53.050 -36.100 ;
        RECT 51.450 -37.500 54.250 -36.300 ;
        RECT 54.650 -37.200 55.050 -35.950 ;
        RECT 54.750 -37.300 55.050 -37.200 ;
        RECT 34.600 -39.150 39.000 -38.150 ;
        RECT 35.000 -39.850 35.200 -39.150 ;
        RECT 36.800 -39.850 37.000 -39.150 ;
        RECT 42.950 -39.300 44.150 -38.000 ;
        RECT 45.850 -38.550 46.550 -37.850 ;
        RECT 51.450 -38.150 53.050 -37.500 ;
        RECT 57.100 -38.400 57.500 -34.850 ;
        RECT 57.900 -37.500 58.300 -34.350 ;
        RECT 58.000 -37.600 58.300 -37.500 ;
        RECT 57.800 -38.250 58.250 -37.800 ;
        RECT 60.900 -38.350 61.300 -34.350 ;
        RECT 66.450 -34.700 66.850 -29.900 ;
        RECT 67.250 -34.700 67.650 -29.900 ;
        RECT 68.250 -32.900 68.650 -30.800 ;
        RECT 69.050 -32.600 69.450 -28.300 ;
        RECT 69.950 -32.700 70.350 -28.300 ;
        RECT 68.250 -33.300 68.950 -32.900 ;
        RECT 22.100 -41.800 22.750 -41.300 ;
        RECT 17.750 -42.100 24.350 -41.800 ;
        RECT 17.750 -42.850 18.100 -42.100 ;
        RECT 18.750 -42.200 24.350 -42.100 ;
        RECT 15.800 -43.150 18.100 -42.850 ;
        RECT 23.850 -42.300 24.350 -42.200 ;
        RECT 23.850 -43.000 24.550 -42.300 ;
        RECT 15.800 -43.250 16.600 -43.150 ;
        RECT 12.850 -44.050 13.550 -43.350 ;
        RECT 6.750 -46.450 9.050 -46.000 ;
        RECT 6.700 -51.050 8.000 -47.900 ;
        RECT 8.650 -51.850 9.050 -46.450 ;
        RECT 9.250 -46.550 9.900 -45.850 ;
        RECT 16.000 -46.350 16.600 -43.250 ;
        RECT 34.900 -43.550 35.300 -39.850 ;
        RECT 35.700 -43.550 36.100 -39.850 ;
        RECT 36.700 -43.550 37.100 -39.850 ;
        RECT 37.500 -43.550 37.900 -39.850 ;
        RECT 38.300 -43.550 38.700 -39.850 ;
        RECT 42.100 -41.350 43.050 -40.250 ;
        RECT 42.450 -41.850 42.750 -41.350 ;
        RECT 41.550 -42.450 42.150 -42.250 ;
        RECT 42.350 -42.450 42.850 -41.850 ;
        RECT 40.550 -42.900 42.150 -42.450 ;
        RECT 35.100 -44.350 35.600 -43.850 ;
        RECT 35.800 -43.950 36.000 -43.550 ;
        RECT 35.800 -44.350 37.300 -43.950 ;
        RECT 37.700 -44.250 38.200 -43.750 ;
        RECT 38.400 -44.350 38.600 -43.550 ;
        RECT 40.550 -44.350 41.000 -42.900 ;
        RECT 41.550 -42.950 42.150 -42.900 ;
        RECT 42.350 -43.250 42.850 -42.650 ;
        RECT 45.050 -42.750 45.450 -38.950 ;
        RECT 45.850 -42.750 46.250 -38.550 ;
        RECT 55.350 -39.100 57.500 -38.400 ;
        RECT 62.500 -38.600 62.900 -37.550 ;
        RECT 62.000 -39.000 62.950 -38.600 ;
        RECT 62.450 -39.100 62.950 -39.000 ;
        RECT 53.200 -42.400 54.400 -41.100 ;
        RECT 55.350 -41.200 56.350 -39.100 ;
        RECT 57.100 -41.250 57.500 -39.100 ;
        RECT 57.900 -41.250 58.300 -39.350 ;
        RECT 60.900 -40.400 61.300 -39.750 ;
        RECT 57.100 -41.950 57.800 -41.550 ;
        RECT 35.800 -45.400 36.000 -44.350 ;
        RECT 38.400 -44.750 41.000 -44.350 ;
        RECT 38.400 -44.800 38.600 -44.750 ;
        RECT 37.600 -45.000 38.600 -44.800 ;
        RECT 42.450 -44.850 42.850 -43.250 ;
        RECT 43.350 -43.250 43.950 -43.150 ;
        RECT 45.150 -43.250 45.350 -42.750 ;
        RECT 43.350 -43.450 45.350 -43.250 ;
        RECT 43.350 -43.750 43.950 -43.450 ;
        RECT 45.150 -44.050 45.350 -43.450 ;
        RECT 45.750 -43.750 46.350 -43.050 ;
        RECT 57.100 -43.200 57.400 -41.950 ;
        RECT 58.000 -42.400 58.300 -41.250 ;
        RECT 60.500 -40.800 61.300 -40.400 ;
        RECT 62.500 -40.550 62.900 -39.100 ;
        RECT 60.500 -41.200 61.950 -40.800 ;
        RECT 58.000 -42.450 58.800 -42.400 ;
        RECT 60.500 -42.450 60.850 -41.200 ;
        RECT 57.600 -42.900 60.850 -42.450 ;
        RECT 57.600 -42.950 58.300 -42.900 ;
        RECT 37.600 -45.400 37.800 -45.000 ;
        RECT 18.750 -45.800 23.550 -45.400 ;
        RECT 13.700 -46.750 16.600 -46.350 ;
        RECT 19.550 -46.400 22.950 -45.800 ;
        RECT 18.750 -46.800 23.550 -46.400 ;
        RECT 9.450 -51.050 9.850 -47.050 ;
        RECT 18.750 -47.600 23.550 -47.200 ;
        RECT 23.850 -47.400 24.550 -46.700 ;
        RECT 11.350 -49.100 12.550 -47.800 ;
        RECT 20.250 -48.300 22.050 -47.600 ;
        RECT 18.910 -49.050 23.610 -48.300 ;
        RECT 27.200 -49.250 30.600 -47.750 ;
        RECT 9.450 -52.050 23.800 -51.050 ;
        RECT 9.450 -52.200 9.850 -52.050 ;
        RECT 15.550 -52.500 15.800 -52.050 ;
        RECT 17.050 -52.500 17.300 -52.050 ;
        RECT 18.550 -52.500 18.800 -52.050 ;
        RECT 20.050 -52.500 20.300 -52.050 ;
        RECT 21.550 -52.500 21.800 -52.050 ;
        RECT 15.450 -54.400 15.850 -52.500 ;
        RECT 16.100 -54.400 16.500 -52.500 ;
        RECT 16.950 -54.400 17.350 -52.500 ;
        RECT 17.600 -54.400 18.000 -52.500 ;
        RECT 18.450 -54.400 18.850 -52.500 ;
        RECT 19.100 -54.400 19.500 -52.500 ;
        RECT 19.950 -54.400 20.350 -52.500 ;
        RECT 20.600 -54.400 21.000 -52.500 ;
        RECT 21.450 -54.400 21.850 -52.500 ;
        RECT 22.100 -54.400 22.500 -52.500 ;
        RECT 5.700 -54.950 13.500 -54.600 ;
        RECT 5.700 -65.700 6.100 -54.950 ;
        RECT 13.150 -57.750 13.500 -54.950 ;
        RECT 15.550 -57.750 15.950 -57.650 ;
        RECT 13.150 -57.950 15.950 -57.750 ;
        RECT 15.550 -58.050 15.950 -57.950 ;
        RECT 16.200 -57.750 16.400 -54.400 ;
        RECT 17.050 -57.750 17.450 -57.650 ;
        RECT 16.200 -57.950 17.450 -57.750 ;
        RECT 16.200 -58.300 16.400 -57.950 ;
        RECT 17.050 -58.050 17.450 -57.950 ;
        RECT 17.700 -57.750 17.900 -54.400 ;
        RECT 18.550 -57.750 18.950 -57.650 ;
        RECT 17.700 -57.950 18.950 -57.750 ;
        RECT 17.700 -58.300 17.900 -57.950 ;
        RECT 18.550 -58.050 18.950 -57.950 ;
        RECT 19.200 -57.750 19.400 -54.400 ;
        RECT 20.050 -57.750 20.450 -57.650 ;
        RECT 19.200 -57.950 20.450 -57.750 ;
        RECT 19.200 -58.300 19.400 -57.950 ;
        RECT 20.050 -58.050 20.450 -57.950 ;
        RECT 20.700 -57.750 20.900 -54.400 ;
        RECT 21.550 -57.750 21.950 -57.650 ;
        RECT 20.700 -57.950 21.950 -57.750 ;
        RECT 20.700 -58.300 20.900 -57.950 ;
        RECT 21.550 -58.050 21.950 -57.950 ;
        RECT 22.200 -57.750 22.400 -54.400 ;
        RECT 22.200 -57.950 25.350 -57.750 ;
        RECT 22.200 -58.300 22.400 -57.950 ;
        RECT 15.450 -60.200 15.850 -58.300 ;
        RECT 16.100 -60.200 16.500 -58.300 ;
        RECT 16.950 -60.200 17.350 -58.300 ;
        RECT 17.600 -60.200 18.000 -58.300 ;
        RECT 18.450 -60.200 18.850 -58.300 ;
        RECT 19.100 -60.200 19.500 -58.300 ;
        RECT 19.950 -60.200 20.350 -58.300 ;
        RECT 20.600 -60.200 21.000 -58.300 ;
        RECT 21.450 -60.200 21.850 -58.300 ;
        RECT 22.100 -60.200 22.500 -58.300 ;
        RECT 15.550 -60.650 15.750 -60.200 ;
        RECT 16.550 -60.650 17.000 -60.450 ;
        RECT 15.550 -60.850 17.000 -60.650 ;
        RECT 18.550 -60.650 18.750 -60.200 ;
        RECT 19.550 -60.650 20.000 -60.450 ;
        RECT 18.550 -60.850 20.000 -60.650 ;
        RECT 21.550 -60.650 21.750 -60.200 ;
        RECT 25.050 -60.350 25.350 -57.950 ;
        RECT 27.450 -59.750 27.850 -49.250 ;
        RECT 28.250 -59.750 29.550 -50.150 ;
        RECT 29.950 -59.750 30.350 -49.250 ;
        RECT 34.900 -50.200 35.300 -45.400 ;
        RECT 35.700 -50.200 36.100 -45.400 ;
        RECT 36.700 -50.200 37.100 -45.400 ;
        RECT 37.500 -50.200 37.900 -45.400 ;
        RECT 38.300 -50.200 38.700 -45.400 ;
        RECT 44.050 -46.600 44.450 -44.050 ;
        RECT 45.050 -45.850 45.450 -44.050 ;
        RECT 45.850 -46.600 46.250 -44.050 ;
        RECT 53.200 -44.850 54.400 -43.550 ;
        RECT 44.050 -47.850 46.250 -46.600 ;
        RECT 55.350 -46.400 56.350 -46.200 ;
        RECT 57.100 -46.400 57.500 -43.200 ;
        RECT 55.350 -48.000 57.500 -46.400 ;
        RECT 57.900 -46.900 58.300 -43.200 ;
        RECT 60.450 -44.000 60.850 -42.900 ;
        RECT 63.050 -43.700 63.450 -42.900 ;
        RECT 60.450 -44.350 61.350 -44.000 ;
        RECT 60.900 -44.400 61.350 -44.350 ;
        RECT 63.150 -46.900 63.450 -43.700 ;
        RECT 63.950 -46.800 64.350 -35.900 ;
        RECT 64.750 -43.700 65.150 -35.100 ;
        RECT 66.450 -35.800 66.750 -34.700 ;
        RECT 65.550 -46.800 65.950 -35.900 ;
        RECT 66.450 -36.300 66.950 -35.800 ;
        RECT 66.450 -38.100 66.750 -36.300 ;
        RECT 66.950 -37.700 67.350 -37.300 ;
        RECT 66.450 -41.900 66.850 -38.100 ;
        RECT 66.450 -43.700 66.850 -42.900 ;
        RECT 66.450 -46.800 66.750 -43.700 ;
        RECT 67.250 -44.000 67.650 -38.100 ;
        RECT 66.950 -44.400 67.650 -44.000 ;
        RECT 68.250 -45.500 68.650 -33.300 ;
        RECT 69.050 -35.200 70.350 -34.800 ;
        RECT 69.050 -45.500 69.450 -35.200 ;
        RECT 69.950 -45.500 70.350 -35.200 ;
        RECT 70.750 -45.500 71.150 -30.800 ;
        RECT 71.950 -33.600 72.350 -29.400 ;
        RECT 73.050 -31.200 73.450 -28.300 ;
        RECT 75.150 -29.300 75.450 -28.300 ;
        RECT 75.650 -29.100 76.050 -28.700 ;
        RECT 73.050 -34.100 73.450 -31.800 ;
        RECT 71.950 -34.700 72.450 -34.200 ;
        RECT 73.050 -34.800 73.850 -34.100 ;
        RECT 75.150 -34.200 75.550 -29.300 ;
        RECT 75.950 -34.600 76.350 -29.400 ;
        RECT 77.150 -31.200 77.550 -28.300 ;
        RECT 81.250 -31.550 81.650 -29.400 ;
        RECT 78.950 -32.050 81.650 -31.550 ;
        RECT 81.250 -32.500 81.650 -32.050 ;
        RECT 80.750 -34.150 81.750 -32.500 ;
        RECT 83.000 -33.900 84.700 -32.300 ;
        RECT 75.950 -34.800 76.550 -34.600 ;
        RECT 71.950 -43.900 72.350 -35.500 ;
        RECT 73.050 -39.300 73.450 -34.800 ;
        RECT 75.650 -35.100 76.550 -34.800 ;
        RECT 78.450 -34.950 81.750 -34.150 ;
        RECT 75.650 -35.200 76.350 -35.100 ;
        RECT 75.150 -39.900 75.550 -35.500 ;
        RECT 75.950 -39.300 76.350 -35.200 ;
        RECT 78.450 -36.550 78.950 -34.950 ;
        RECT 80.750 -35.000 81.750 -34.950 ;
        RECT 83.000 -36.700 84.700 -35.100 ;
        RECT 75.150 -40.000 75.650 -39.900 ;
        RECT 68.100 -46.500 69.100 -45.800 ;
        RECT 70.250 -46.500 71.250 -45.800 ;
        RECT 73.050 -46.800 73.450 -40.100 ;
        RECT 75.150 -40.400 75.850 -40.000 ;
        RECT 75.150 -44.600 75.550 -40.400 ;
        RECT 75.950 -46.800 76.350 -40.700 ;
        RECT 78.250 -46.500 78.650 -36.900 ;
        RECT 79.050 -38.300 79.550 -36.900 ;
        RECT 83.000 -39.250 84.700 -37.650 ;
        RECT 78.950 -40.400 79.400 -39.950 ;
        RECT 80.750 -40.650 81.750 -40.000 ;
        RECT 79.050 -41.600 81.750 -40.650 ;
        RECT 79.050 -43.400 79.450 -41.600 ;
        RECT 80.750 -42.500 81.750 -41.600 ;
        RECT 83.000 -42.300 84.700 -40.700 ;
        RECT 78.950 -44.500 79.450 -43.600 ;
        RECT 80.450 -45.700 80.950 -45.350 ;
        RECT 79.100 -46.000 82.200 -45.700 ;
        RECT 79.200 -46.100 82.200 -46.000 ;
        RECT 78.250 -46.800 80.100 -46.500 ;
        RECT 63.950 -46.900 80.100 -46.800 ;
        RECT 80.450 -46.850 81.000 -46.300 ;
        RECT 83.000 -46.500 84.700 -45.700 ;
        RECT 81.300 -46.900 84.700 -46.500 ;
        RECT 57.900 -47.550 78.650 -46.900 ;
        RECT 83.000 -47.300 84.700 -46.900 ;
        RECT 57.900 -47.600 74.300 -47.550 ;
        RECT 64.120 -47.720 74.300 -47.600 ;
        RECT 55.350 -48.700 56.350 -48.000 ;
        RECT 35.000 -51.000 35.200 -50.200 ;
        RECT 36.800 -51.000 37.000 -50.200 ;
        RECT 38.400 -51.000 38.600 -50.200 ;
        RECT 34.600 -52.100 39.000 -51.000 ;
        RECT 35.000 -52.900 35.200 -52.100 ;
        RECT 36.800 -52.900 37.000 -52.100 ;
        RECT 38.400 -52.900 38.600 -52.100 ;
        RECT 43.400 -52.300 46.800 -51.350 ;
        RECT 43.400 -52.750 43.600 -52.300 ;
        RECT 44.900 -52.750 45.100 -52.300 ;
        RECT 46.600 -52.700 46.800 -52.300 ;
        RECT 34.900 -57.700 35.300 -52.900 ;
        RECT 35.700 -57.700 36.100 -52.900 ;
        RECT 36.700 -57.700 37.100 -52.900 ;
        RECT 37.500 -57.700 37.900 -52.900 ;
        RECT 38.300 -57.700 38.700 -52.900 ;
        RECT 42.550 -54.550 42.950 -52.750 ;
        RECT 43.300 -54.550 43.700 -52.750 ;
        RECT 44.050 -54.550 44.450 -52.750 ;
        RECT 44.800 -54.550 45.200 -52.750 ;
        RECT 45.700 -54.500 46.100 -52.700 ;
        RECT 46.500 -54.500 46.900 -52.700 ;
        RECT 63.950 -54.200 65.350 -53.900 ;
        RECT 42.650 -55.000 42.850 -54.550 ;
        RECT 44.150 -55.000 44.350 -54.550 ;
        RECT 42.650 -55.200 44.350 -55.000 ;
        RECT 45.000 -54.950 45.400 -54.850 ;
        RECT 45.800 -54.950 46.000 -54.500 ;
        RECT 45.000 -55.150 46.000 -54.950 ;
        RECT 43.450 -55.500 43.900 -55.200 ;
        RECT 45.000 -55.250 45.400 -55.150 ;
        RECT 42.850 -55.800 44.650 -55.500 ;
        RECT 45.800 -55.800 46.000 -55.150 ;
        RECT 46.300 -55.500 47.000 -54.800 ;
        RECT 42.850 -56.200 43.150 -55.800 ;
        RECT 44.350 -56.200 44.650 -55.800 ;
        RECT 35.000 -59.050 35.500 -58.550 ;
        RECT 35.800 -58.650 36.000 -57.700 ;
        RECT 37.600 -58.100 37.800 -57.700 ;
        RECT 38.450 -58.100 41.750 -58.000 ;
        RECT 37.600 -58.300 41.750 -58.100 ;
        RECT 38.400 -58.400 41.750 -58.300 ;
        RECT 35.800 -59.050 37.300 -58.650 ;
        RECT 35.800 -59.450 36.000 -59.050 ;
        RECT 37.700 -59.250 38.200 -58.750 ;
        RECT 38.400 -59.450 38.600 -58.400 ;
        RECT 41.400 -59.100 41.750 -58.400 ;
        RECT 42.100 -58.500 42.500 -56.200 ;
        RECT 42.800 -58.500 43.200 -56.200 ;
        RECT 43.500 -58.500 43.900 -56.200 ;
        RECT 44.300 -58.500 44.700 -56.200 ;
        RECT 42.150 -59.100 42.450 -58.500 ;
        RECT 43.550 -59.100 43.850 -58.500 ;
        RECT 42.150 -59.350 43.850 -59.100 ;
        RECT 27.250 -60.350 28.000 -60.200 ;
        RECT 22.550 -60.650 23.000 -60.450 ;
        RECT 21.550 -60.850 23.000 -60.650 ;
        RECT 25.050 -60.800 28.000 -60.350 ;
        RECT 15.550 -61.100 15.750 -60.850 ;
        RECT 16.550 -61.100 16.750 -60.850 ;
        RECT 18.550 -61.100 18.750 -60.850 ;
        RECT 19.550 -61.100 19.750 -60.850 ;
        RECT 21.550 -61.100 21.750 -60.850 ;
        RECT 22.550 -61.100 22.750 -60.850 ;
        RECT 27.250 -60.950 28.000 -60.800 ;
        RECT 28.650 -60.750 29.150 -59.750 ;
        RECT 29.700 -60.550 30.300 -60.000 ;
        RECT 14.800 -64.000 15.200 -61.100 ;
        RECT 15.450 -64.000 15.850 -61.100 ;
        RECT 14.800 -66.050 15.000 -64.000 ;
        RECT 15.250 -64.700 15.650 -64.300 ;
        RECT 16.350 -65.500 16.750 -61.100 ;
        RECT 17.000 -65.500 17.400 -61.100 ;
        RECT 17.800 -64.000 18.200 -61.100 ;
        RECT 18.450 -64.000 18.850 -61.100 ;
        RECT 17.100 -66.050 17.300 -65.500 ;
        RECT 17.800 -66.050 18.000 -64.000 ;
        RECT 18.250 -64.700 18.650 -64.300 ;
        RECT 19.350 -65.500 19.750 -61.100 ;
        RECT 20.000 -65.500 20.400 -61.100 ;
        RECT 20.800 -64.000 21.200 -61.100 ;
        RECT 21.450 -64.000 21.850 -61.100 ;
        RECT 20.100 -66.050 20.300 -65.500 ;
        RECT 20.800 -66.050 21.000 -64.000 ;
        RECT 21.250 -64.700 21.650 -64.300 ;
        RECT 22.350 -65.500 22.750 -61.100 ;
        RECT 23.000 -65.500 23.400 -61.100 ;
        RECT 28.650 -61.150 31.550 -60.750 ;
        RECT 23.100 -66.050 23.300 -65.500 ;
        RECT 5.000 -67.150 6.000 -66.200 ;
        RECT 14.250 -67.050 23.800 -66.050 ;
        RECT 25.100 -67.550 27.050 -67.250 ;
        RECT 27.450 -67.550 27.850 -61.350 ;
        RECT 25.100 -68.550 27.850 -67.550 ;
        RECT 28.250 -68.150 29.550 -61.350 ;
        RECT 29.950 -68.150 30.350 -61.150 ;
        RECT 30.750 -61.500 31.550 -61.150 ;
        RECT 34.900 -63.150 35.300 -59.450 ;
        RECT 35.700 -63.150 36.100 -59.450 ;
        RECT 36.700 -63.150 37.100 -59.450 ;
        RECT 37.500 -63.150 37.900 -59.450 ;
        RECT 38.300 -63.150 38.700 -59.450 ;
        RECT 42.150 -59.550 42.450 -59.350 ;
        RECT 41.900 -60.400 42.750 -59.550 ;
        RECT 45.700 -59.600 46.100 -55.800 ;
        RECT 46.500 -59.600 46.900 -55.800 ;
        RECT 48.700 -58.150 49.900 -56.850 ;
        RECT 54.150 -59.400 56.850 -59.250 ;
        RECT 46.600 -59.850 46.800 -59.600 ;
        RECT 53.800 -59.800 58.100 -59.400 ;
        RECT 46.600 -60.550 47.300 -59.850 ;
        RECT 54.200 -60.300 54.400 -59.800 ;
        RECT 55.800 -60.300 56.000 -59.800 ;
        RECT 62.300 -59.900 62.700 -54.500 ;
        RECT 63.100 -54.650 65.350 -54.200 ;
        RECT 63.100 -59.300 63.500 -54.650 ;
        RECT 63.950 -55.000 65.350 -54.650 ;
        RECT 54.100 -61.100 54.500 -60.300 ;
        RECT 54.900 -61.100 55.300 -60.300 ;
        RECT 55.700 -61.100 56.100 -60.300 ;
        RECT 56.500 -61.100 56.900 -60.300 ;
        RECT 61.850 -60.450 62.700 -59.900 ;
        RECT 40.600 -61.650 41.050 -61.200 ;
        RECT 54.400 -61.500 54.800 -61.400 ;
        RECT 52.850 -61.800 54.800 -61.500 ;
        RECT 55.000 -61.500 55.200 -61.100 ;
        RECT 56.600 -61.400 56.900 -61.100 ;
        RECT 55.900 -61.500 56.400 -61.400 ;
        RECT 55.000 -61.700 56.400 -61.500 ;
        RECT 56.600 -61.700 57.700 -61.400 ;
        RECT 55.900 -61.800 56.400 -61.700 ;
        RECT 57.400 -61.750 57.700 -61.700 ;
        RECT 52.850 -62.050 54.050 -61.800 ;
        RECT 35.000 -63.750 35.200 -63.150 ;
        RECT 36.800 -63.750 37.000 -63.150 ;
        RECT 40.100 -63.400 40.500 -62.150 ;
        RECT 38.550 -63.750 40.500 -63.400 ;
        RECT 34.600 -64.400 40.500 -63.750 ;
        RECT 34.600 -64.750 39.000 -64.400 ;
        RECT 35.000 -65.550 35.200 -64.750 ;
        RECT 36.800 -65.550 37.000 -64.750 ;
        RECT 34.900 -69.250 35.300 -65.550 ;
        RECT 35.700 -69.250 36.100 -65.550 ;
        RECT 36.700 -69.250 37.100 -65.550 ;
        RECT 37.500 -69.250 37.900 -65.550 ;
        RECT 38.300 -69.250 38.700 -65.550 ;
        RECT 40.100 -65.950 40.500 -64.400 ;
        RECT 40.900 -63.600 41.300 -62.150 ;
        RECT 55.050 -62.400 55.600 -61.950 ;
        RECT 55.900 -63.000 56.100 -61.800 ;
        RECT 57.400 -62.300 58.250 -61.750 ;
        RECT 57.400 -63.000 57.700 -62.300 ;
        RECT 54.000 -63.500 54.600 -63.000 ;
        RECT 54.800 -63.500 55.400 -63.000 ;
        RECT 55.600 -63.500 56.200 -63.000 ;
        RECT 56.500 -63.500 57.100 -63.000 ;
        RECT 57.300 -63.500 57.900 -63.000 ;
        RECT 62.300 -63.100 62.700 -60.450 ;
        RECT 62.900 -60.500 63.700 -59.800 ;
        RECT 40.900 -64.300 42.150 -63.600 ;
        RECT 54.200 -63.900 54.400 -63.500 ;
        RECT 56.600 -63.900 56.800 -63.500 ;
        RECT 63.100 -63.850 63.500 -60.800 ;
        RECT 53.800 -64.300 58.100 -63.900 ;
        RECT 40.900 -65.950 41.300 -64.300 ;
        RECT 54.150 -64.600 56.850 -64.300 ;
        RECT 61.950 -64.850 63.500 -63.850 ;
        RECT 44.050 -68.950 44.950 -68.200 ;
        RECT 41.550 -69.250 44.950 -68.950 ;
        RECT 35.000 -70.050 35.500 -69.550 ;
        RECT 35.800 -69.650 36.000 -69.250 ;
        RECT 38.400 -69.450 38.600 -69.250 ;
        RECT 41.550 -69.300 44.850 -69.250 ;
        RECT 35.800 -70.050 37.300 -69.650 ;
        RECT 37.700 -69.950 38.200 -69.450 ;
        RECT 38.400 -69.900 41.250 -69.450 ;
        RECT 41.550 -69.850 41.850 -69.300 ;
        RECT 43.050 -69.850 43.350 -69.300 ;
        RECT 44.550 -69.850 44.850 -69.300 ;
        RECT 47.350 -69.850 47.850 -69.350 ;
        RECT 35.800 -71.000 36.000 -70.050 ;
        RECT 38.400 -70.400 38.600 -69.900 ;
        RECT 37.600 -70.600 38.600 -70.400 ;
        RECT 37.600 -71.000 37.800 -70.600 ;
        RECT 9.500 -72.700 13.750 -71.740 ;
        RECT 11.550 -76.300 11.950 -72.700 ;
        RECT 16.350 -72.800 17.050 -72.500 ;
        RECT 16.350 -73.200 17.550 -72.800 ;
        RECT 18.350 -73.200 19.050 -72.500 ;
        RECT 17.150 -73.500 17.550 -73.200 ;
        RECT 17.150 -76.300 18.450 -73.500 ;
        RECT 18.850 -74.700 19.250 -73.500 ;
        RECT 18.850 -75.500 26.050 -74.700 ;
        RECT 18.850 -76.800 19.250 -75.500 ;
        RECT 14.650 -77.200 19.250 -76.800 ;
        RECT 14.650 -79.700 15.050 -77.200 ;
        RECT 9.150 -82.200 9.550 -79.700 ;
        RECT 13.750 -80.500 15.050 -79.700 ;
        RECT 11.350 -81.500 12.050 -80.800 ;
        RECT 16.850 -81.500 17.550 -80.800 ;
        RECT 19.250 -82.200 19.650 -77.700 ;
        RECT 20.150 -82.200 20.550 -76.400 ;
        RECT 24.750 -80.500 25.150 -75.500 ;
        RECT 25.650 -80.500 26.050 -75.500 ;
        RECT 22.250 -81.500 22.950 -80.800 ;
        RECT 27.850 -81.500 28.550 -80.800 ;
        RECT 30.250 -82.200 30.650 -74.700 ;
        RECT 34.900 -75.800 35.300 -71.000 ;
        RECT 35.700 -75.800 36.100 -71.000 ;
        RECT 36.700 -75.800 37.100 -71.000 ;
        RECT 37.500 -75.800 37.900 -71.000 ;
        RECT 38.300 -75.800 38.700 -71.000 ;
        RECT 41.500 -75.650 41.900 -69.850 ;
        RECT 42.250 -75.650 42.650 -69.850 ;
        RECT 43.000 -75.650 43.400 -69.850 ;
        RECT 43.750 -75.650 44.150 -69.850 ;
        RECT 44.500 -75.650 44.900 -69.850 ;
        RECT 45.250 -75.650 45.650 -69.850 ;
        RECT 47.350 -70.150 47.650 -69.850 ;
        RECT 35.000 -76.600 35.200 -75.800 ;
        RECT 36.800 -76.600 37.000 -75.800 ;
        RECT 38.400 -76.600 38.600 -75.800 ;
        RECT 42.300 -76.250 42.600 -75.650 ;
        RECT 43.800 -76.250 44.100 -75.650 ;
        RECT 45.300 -76.250 45.600 -75.650 ;
        RECT 46.550 -75.950 46.950 -70.150 ;
        RECT 47.300 -75.950 47.700 -70.150 ;
        RECT 48.750 -74.050 49.950 -72.750 ;
        RECT 42.300 -76.450 45.600 -76.250 ;
        RECT 34.600 -77.600 39.000 -76.600 ;
        RECT 43.100 -76.700 44.900 -76.450 ;
        RECT 46.650 -76.650 46.850 -75.950 ;
        RECT 43.100 -77.350 43.400 -76.700 ;
        RECT 44.600 -77.350 44.900 -76.700 ;
        RECT 45.450 -77.050 46.850 -76.650 ;
        RECT 43.050 -80.150 43.450 -77.350 ;
        RECT 43.800 -80.150 44.200 -77.350 ;
        RECT 44.550 -80.150 44.950 -77.350 ;
        RECT 45.300 -80.150 45.700 -77.350 ;
        RECT 46.650 -77.950 46.850 -77.050 ;
        RECT 47.100 -77.150 47.800 -76.450 ;
        RECT 46.550 -79.750 46.950 -77.950 ;
        RECT 47.300 -79.750 47.700 -77.950 ;
        RECT 43.850 -80.750 44.150 -80.150 ;
        RECT 45.350 -80.750 45.650 -80.150 ;
        RECT 47.350 -80.750 47.650 -79.750 ;
        RECT 43.850 -81.450 47.650 -80.750 ;
        RECT 8.550 -83.750 32.650 -82.200 ;
      LAYER met1 ;
        RECT 12.600 34.500 14.900 35.700 ;
        RECT 21.000 34.500 23.300 35.700 ;
        RECT 32.700 34.500 35.000 35.700 ;
        RECT 42.100 34.500 44.400 35.700 ;
        RECT 53.900 34.500 56.200 35.700 ;
        RECT 64.400 34.500 66.700 35.700 ;
        RECT 16.200 32.700 16.600 32.800 ;
        RECT 8.500 32.500 16.600 32.700 ;
        RECT 8.500 31.600 8.700 32.500 ;
        RECT 16.200 32.400 16.600 32.500 ;
        RECT 19.400 32.700 19.900 32.900 ;
        RECT 26.900 32.700 27.300 32.800 ;
        RECT 19.400 32.500 27.300 32.700 ;
        RECT 19.400 32.400 19.900 32.500 ;
        RECT 17.000 31.900 17.400 32.300 ;
        RECT 8.500 31.000 9.100 31.600 ;
        RECT 3.800 27.500 4.200 27.600 ;
        RECT 1.300 27.300 4.200 27.500 ;
        RECT 8.500 27.400 8.700 31.000 ;
        RECT 12.400 27.500 12.800 27.600 ;
        RECT 1.300 27.100 1.500 27.300 ;
        RECT 3.800 27.200 4.200 27.300 ;
        RECT 8.400 27.300 8.800 27.400 ;
        RECT 9.900 27.300 12.800 27.500 ;
        RECT 17.100 27.400 17.300 31.900 ;
        RECT 17.700 29.700 20.100 30.800 ;
        RECT 20.600 27.500 20.800 32.500 ;
        RECT 26.900 32.400 27.300 32.500 ;
        RECT 30.100 32.700 30.600 32.900 ;
        RECT 37.600 32.700 38.000 32.800 ;
        RECT 30.100 32.500 38.000 32.700 ;
        RECT 30.100 32.400 30.600 32.500 ;
        RECT 27.700 31.900 28.100 32.300 ;
        RECT 23.100 27.500 23.500 27.600 ;
        RECT 8.400 27.100 10.100 27.300 ;
        RECT 12.400 27.200 12.800 27.300 ;
        RECT 17.000 27.300 17.400 27.400 ;
        RECT 17.800 27.300 18.400 27.500 ;
        RECT 17.000 27.100 18.400 27.300 ;
        RECT 20.600 27.300 23.500 27.500 ;
        RECT 27.800 27.400 28.000 31.900 ;
        RECT 28.400 29.700 30.800 30.800 ;
        RECT 31.300 27.500 31.500 32.500 ;
        RECT 37.600 32.400 38.000 32.500 ;
        RECT 40.800 32.700 41.300 32.900 ;
        RECT 48.300 32.700 48.700 32.800 ;
        RECT 40.800 32.500 48.700 32.700 ;
        RECT 40.800 32.400 41.300 32.500 ;
        RECT 38.400 31.900 38.800 32.300 ;
        RECT 33.800 27.500 34.200 27.600 ;
        RECT 20.600 27.100 20.800 27.300 ;
        RECT 23.100 27.200 23.500 27.300 ;
        RECT 27.700 27.300 28.100 27.400 ;
        RECT 28.500 27.300 29.100 27.500 ;
        RECT 27.700 27.100 29.100 27.300 ;
        RECT 31.300 27.300 34.200 27.500 ;
        RECT 38.500 27.400 38.700 31.900 ;
        RECT 39.100 29.700 41.500 30.800 ;
        RECT 42.000 27.500 42.200 32.500 ;
        RECT 48.300 32.400 48.700 32.500 ;
        RECT 51.500 32.700 52.000 32.900 ;
        RECT 59.000 32.700 59.400 32.800 ;
        RECT 51.500 32.500 59.400 32.700 ;
        RECT 51.500 32.400 52.000 32.500 ;
        RECT 49.100 31.900 49.500 32.300 ;
        RECT 44.500 27.500 44.900 27.600 ;
        RECT 31.300 27.100 31.500 27.300 ;
        RECT 33.800 27.200 34.200 27.300 ;
        RECT 38.400 27.300 38.800 27.400 ;
        RECT 39.200 27.300 39.800 27.500 ;
        RECT 38.400 27.100 39.800 27.300 ;
        RECT 42.000 27.300 44.900 27.500 ;
        RECT 49.200 27.400 49.400 31.900 ;
        RECT 49.800 29.700 52.200 30.800 ;
        RECT 52.700 27.500 52.900 32.500 ;
        RECT 59.000 32.400 59.400 32.500 ;
        RECT 62.200 32.700 62.700 32.900 ;
        RECT 69.700 32.700 70.100 32.800 ;
        RECT 62.200 32.500 70.100 32.700 ;
        RECT 62.200 32.400 62.700 32.500 ;
        RECT 59.800 31.900 60.200 32.300 ;
        RECT 55.200 27.500 55.600 27.600 ;
        RECT 42.000 27.100 42.200 27.300 ;
        RECT 44.500 27.200 44.900 27.300 ;
        RECT 49.100 27.300 49.500 27.400 ;
        RECT 49.900 27.300 50.500 27.500 ;
        RECT 49.100 27.100 50.500 27.300 ;
        RECT 52.700 27.300 55.600 27.500 ;
        RECT 59.900 27.400 60.100 31.900 ;
        RECT 60.500 29.700 62.900 30.800 ;
        RECT 63.400 27.500 63.600 32.500 ;
        RECT 69.700 32.400 70.100 32.500 ;
        RECT 72.900 32.700 73.400 32.900 ;
        RECT 72.900 32.500 74.300 32.700 ;
        RECT 72.900 32.400 73.400 32.500 ;
        RECT 70.500 31.900 70.900 32.300 ;
        RECT 65.900 27.500 66.300 27.600 ;
        RECT 52.700 27.100 52.900 27.300 ;
        RECT 55.200 27.200 55.600 27.300 ;
        RECT 59.800 27.300 60.200 27.400 ;
        RECT 60.600 27.300 61.200 27.500 ;
        RECT 59.800 27.100 61.200 27.300 ;
        RECT 63.400 27.300 66.300 27.500 ;
        RECT 70.600 27.400 70.800 31.900 ;
        RECT 71.200 29.700 73.600 30.800 ;
        RECT 74.100 27.500 74.300 32.500 ;
        RECT 76.600 27.500 77.000 27.600 ;
        RECT 63.400 27.100 63.600 27.300 ;
        RECT 65.900 27.200 66.300 27.300 ;
        RECT 70.500 27.300 70.900 27.400 ;
        RECT 71.300 27.300 71.900 27.500 ;
        RECT 70.500 27.100 71.900 27.300 ;
        RECT 74.100 27.300 77.000 27.500 ;
        RECT 74.100 27.100 74.300 27.300 ;
        RECT 76.600 27.200 77.000 27.300 ;
        RECT 81.200 27.300 81.600 27.400 ;
        RECT 82.000 27.300 82.600 27.500 ;
        RECT 81.200 27.100 82.600 27.300 ;
        RECT 1.200 26.700 1.600 27.100 ;
        RECT 8.400 27.000 8.800 27.100 ;
        RECT 4.800 26.200 5.400 26.800 ;
        RECT 8.600 18.700 8.800 27.000 ;
        RECT 9.800 26.700 10.200 27.100 ;
        RECT 17.000 27.000 17.400 27.100 ;
        RECT 13.400 26.200 14.000 26.800 ;
        RECT 17.200 18.700 17.400 27.000 ;
        RECT 17.800 26.900 18.400 27.100 ;
        RECT 20.500 26.700 20.900 27.100 ;
        RECT 27.700 27.000 28.100 27.100 ;
        RECT 24.100 26.200 24.700 26.800 ;
        RECT 18.000 21.300 20.300 22.500 ;
        RECT 27.900 18.700 28.100 27.000 ;
        RECT 28.500 26.900 29.100 27.100 ;
        RECT 31.200 26.700 31.600 27.100 ;
        RECT 38.400 27.000 38.800 27.100 ;
        RECT 34.800 26.200 35.400 26.800 ;
        RECT 28.700 21.300 31.000 22.500 ;
        RECT 38.600 18.700 38.800 27.000 ;
        RECT 39.200 26.900 39.800 27.100 ;
        RECT 41.900 26.700 42.300 27.100 ;
        RECT 49.100 27.000 49.500 27.100 ;
        RECT 45.500 26.200 46.100 26.800 ;
        RECT 39.400 21.300 41.700 22.500 ;
        RECT 49.300 18.700 49.500 27.000 ;
        RECT 49.900 26.900 50.500 27.100 ;
        RECT 52.600 26.700 53.000 27.100 ;
        RECT 59.800 27.000 60.200 27.100 ;
        RECT 56.200 26.200 56.800 26.800 ;
        RECT 50.100 21.300 52.400 22.500 ;
        RECT 60.000 18.700 60.200 27.000 ;
        RECT 60.600 26.900 61.200 27.100 ;
        RECT 63.300 26.700 63.700 27.100 ;
        RECT 70.500 27.000 70.900 27.100 ;
        RECT 66.900 26.200 67.500 26.800 ;
        RECT 60.800 21.300 63.100 22.500 ;
        RECT 70.700 18.700 70.900 27.000 ;
        RECT 71.300 26.900 71.900 27.100 ;
        RECT 74.000 26.700 74.400 27.100 ;
        RECT 81.200 27.000 81.600 27.100 ;
        RECT 77.600 26.200 78.200 26.800 ;
        RECT 71.500 21.300 73.800 22.500 ;
        RECT 81.400 18.700 81.600 27.000 ;
        RECT 82.000 26.900 82.600 27.100 ;
        RECT 2.800 18.200 3.200 18.500 ;
        RECT 1.100 18.100 3.200 18.200 ;
        RECT 1.100 18.000 3.100 18.100 ;
        RECT 1.100 4.500 1.300 18.000 ;
        RECT 3.600 17.600 4.200 18.200 ;
        RECT 4.400 18.100 5.000 18.700 ;
        RECT 4.600 17.000 4.800 18.100 ;
        RECT 6.400 18.000 7.000 18.600 ;
        RECT 7.300 17.600 7.900 18.200 ;
        RECT 8.100 18.100 8.800 18.700 ;
        RECT 11.400 18.200 11.800 18.500 ;
        RECT 9.700 18.100 11.800 18.200 ;
        RECT 2.000 16.800 4.800 17.000 ;
        RECT 2.000 12.000 2.200 16.800 ;
        RECT 8.400 16.600 8.600 18.100 ;
        RECT 5.700 16.400 8.600 16.600 ;
        RECT 9.700 18.000 11.700 18.100 ;
        RECT 5.000 13.000 5.500 13.200 ;
        RECT 3.800 12.900 5.500 13.000 ;
        RECT 3.700 12.800 5.500 12.900 ;
        RECT 3.700 12.500 4.100 12.800 ;
        RECT 5.000 12.700 5.500 12.800 ;
        RECT 2.800 12.100 3.200 12.500 ;
        RECT 1.900 11.600 2.300 12.000 ;
        RECT 1.800 5.300 2.400 5.900 ;
        RECT 2.900 5.400 3.100 12.100 ;
        RECT 4.400 11.900 5.000 12.500 ;
        RECT 5.700 12.000 5.900 16.400 ;
        RECT 6.500 12.100 6.900 12.500 ;
        RECT 7.300 12.400 7.900 13.000 ;
        RECT 5.600 11.600 6.000 12.000 ;
        RECT 6.500 9.600 6.700 12.100 ;
        RECT 5.700 9.400 6.700 9.600 ;
        RECT 5.700 5.800 5.900 9.400 ;
        RECT 7.500 7.700 7.700 12.400 ;
        RECT 8.100 11.900 8.700 12.500 ;
        RECT 7.500 7.500 9.300 7.700 ;
        RECT 5.600 5.500 6.000 5.800 ;
        RECT 4.400 5.400 6.000 5.500 ;
        RECT 2.700 4.800 3.300 5.400 ;
        RECT 4.400 5.300 5.800 5.400 ;
        RECT 4.400 4.900 5.000 5.300 ;
        RECT 3.700 4.500 4.100 4.900 ;
        RECT 6.400 4.800 7.000 5.400 ;
        RECT 7.500 4.900 7.700 7.500 ;
        RECT 8.100 4.900 8.700 5.500 ;
        RECT 7.400 4.500 7.800 4.900 ;
        RECT 1.100 4.300 4.000 4.500 ;
        RECT 3.800 3.800 4.000 4.300 ;
        RECT 8.400 3.800 8.600 4.900 ;
        RECT 3.800 3.600 8.600 3.800 ;
        RECT 9.100 0.400 9.300 7.500 ;
        RECT 9.700 4.500 9.900 18.000 ;
        RECT 12.200 17.600 12.800 18.200 ;
        RECT 13.000 18.100 13.600 18.700 ;
        RECT 13.200 17.000 13.400 18.100 ;
        RECT 15.000 18.000 15.600 18.600 ;
        RECT 15.900 17.600 16.500 18.200 ;
        RECT 16.700 18.100 17.400 18.700 ;
        RECT 22.100 18.200 22.500 18.500 ;
        RECT 20.400 18.100 22.500 18.200 ;
        RECT 10.600 16.800 13.400 17.000 ;
        RECT 10.600 12.000 10.800 16.800 ;
        RECT 17.000 16.600 17.200 18.100 ;
        RECT 14.300 16.400 17.200 16.600 ;
        RECT 20.400 18.000 22.400 18.100 ;
        RECT 13.600 13.000 14.100 13.200 ;
        RECT 12.400 12.900 14.100 13.000 ;
        RECT 12.300 12.800 14.100 12.900 ;
        RECT 12.300 12.500 12.700 12.800 ;
        RECT 13.600 12.700 14.100 12.800 ;
        RECT 11.400 12.100 11.800 12.500 ;
        RECT 10.500 11.600 10.900 12.000 ;
        RECT 10.400 5.300 11.000 5.900 ;
        RECT 11.500 5.400 11.700 12.100 ;
        RECT 13.000 11.900 13.600 12.500 ;
        RECT 14.300 12.000 14.500 16.400 ;
        RECT 17.600 14.800 20.000 15.900 ;
        RECT 15.100 12.100 15.500 12.500 ;
        RECT 15.900 12.400 16.500 13.000 ;
        RECT 14.200 11.600 14.600 12.000 ;
        RECT 15.100 9.600 15.300 12.100 ;
        RECT 14.300 9.400 15.300 9.600 ;
        RECT 14.300 5.800 14.500 9.400 ;
        RECT 16.100 7.700 16.300 12.400 ;
        RECT 16.700 11.900 17.300 12.500 ;
        RECT 17.400 8.100 19.700 9.300 ;
        RECT 16.100 7.500 17.700 7.700 ;
        RECT 14.200 5.500 14.600 5.800 ;
        RECT 13.000 5.400 14.600 5.500 ;
        RECT 11.300 4.800 11.900 5.400 ;
        RECT 13.000 5.300 14.400 5.400 ;
        RECT 13.000 4.900 13.600 5.300 ;
        RECT 12.300 4.500 12.700 4.900 ;
        RECT 15.000 4.800 15.600 5.400 ;
        RECT 16.100 4.900 16.300 7.500 ;
        RECT 16.700 4.900 17.300 5.500 ;
        RECT 16.000 4.500 16.400 4.900 ;
        RECT 9.700 4.300 12.600 4.500 ;
        RECT 12.400 3.800 12.600 4.300 ;
        RECT 17.000 3.800 17.200 4.900 ;
        RECT 12.400 3.600 17.200 3.800 ;
        RECT 9.700 1.600 12.100 2.700 ;
        RECT 17.500 0.600 17.700 7.500 ;
        RECT 20.400 4.500 20.600 18.000 ;
        RECT 22.900 17.600 23.500 18.200 ;
        RECT 23.700 18.100 24.300 18.700 ;
        RECT 23.900 17.000 24.100 18.100 ;
        RECT 25.700 18.000 26.300 18.600 ;
        RECT 26.600 17.600 27.200 18.200 ;
        RECT 27.400 18.100 28.100 18.700 ;
        RECT 32.800 18.200 33.200 18.500 ;
        RECT 31.100 18.100 33.200 18.200 ;
        RECT 21.300 16.800 24.100 17.000 ;
        RECT 21.300 12.000 21.500 16.800 ;
        RECT 27.700 16.600 27.900 18.100 ;
        RECT 25.000 16.400 27.900 16.600 ;
        RECT 31.100 18.000 33.100 18.100 ;
        RECT 24.300 13.000 24.800 13.200 ;
        RECT 23.100 12.900 24.800 13.000 ;
        RECT 23.000 12.800 24.800 12.900 ;
        RECT 23.000 12.500 23.400 12.800 ;
        RECT 24.300 12.700 24.800 12.800 ;
        RECT 22.100 12.100 22.500 12.500 ;
        RECT 21.200 11.600 21.600 12.000 ;
        RECT 21.100 5.300 21.700 5.900 ;
        RECT 22.200 5.400 22.400 12.100 ;
        RECT 23.700 11.900 24.300 12.500 ;
        RECT 25.000 12.000 25.200 16.400 ;
        RECT 28.300 14.800 30.700 15.900 ;
        RECT 25.800 12.100 26.200 12.500 ;
        RECT 26.600 12.400 27.200 13.000 ;
        RECT 24.900 11.600 25.300 12.000 ;
        RECT 25.800 9.600 26.000 12.100 ;
        RECT 25.000 9.400 26.000 9.600 ;
        RECT 25.000 5.800 25.200 9.400 ;
        RECT 26.800 7.700 27.000 12.400 ;
        RECT 27.400 11.900 28.000 12.500 ;
        RECT 28.000 8.100 30.300 9.300 ;
        RECT 26.800 7.500 28.400 7.700 ;
        RECT 24.900 5.500 25.300 5.800 ;
        RECT 23.700 5.400 25.300 5.500 ;
        RECT 22.000 4.800 22.600 5.400 ;
        RECT 23.700 5.300 25.100 5.400 ;
        RECT 23.700 4.900 24.300 5.300 ;
        RECT 23.000 4.500 23.400 4.900 ;
        RECT 25.700 4.800 26.300 5.400 ;
        RECT 26.800 4.900 27.000 7.500 ;
        RECT 27.400 4.900 28.000 5.500 ;
        RECT 26.700 4.500 27.100 4.900 ;
        RECT 20.400 4.300 23.300 4.500 ;
        RECT 23.100 3.800 23.300 4.300 ;
        RECT 27.700 3.800 27.900 4.900 ;
        RECT 23.100 3.600 27.900 3.800 ;
        RECT 18.500 1.600 20.900 2.700 ;
        RECT 16.900 0.400 17.700 0.600 ;
        RECT 28.200 0.400 28.400 7.500 ;
        RECT 31.100 4.500 31.300 18.000 ;
        RECT 33.600 17.600 34.200 18.200 ;
        RECT 34.400 18.100 35.000 18.700 ;
        RECT 34.600 17.000 34.800 18.100 ;
        RECT 36.400 18.000 37.000 18.600 ;
        RECT 37.300 17.600 37.900 18.200 ;
        RECT 38.100 18.100 38.800 18.700 ;
        RECT 43.500 18.200 43.900 18.500 ;
        RECT 41.800 18.100 43.900 18.200 ;
        RECT 32.000 16.800 34.800 17.000 ;
        RECT 32.000 12.000 32.200 16.800 ;
        RECT 38.400 16.600 38.600 18.100 ;
        RECT 35.700 16.400 38.600 16.600 ;
        RECT 41.800 18.000 43.800 18.100 ;
        RECT 35.000 13.000 35.500 13.200 ;
        RECT 33.800 12.900 35.500 13.000 ;
        RECT 33.700 12.800 35.500 12.900 ;
        RECT 33.700 12.500 34.100 12.800 ;
        RECT 35.000 12.700 35.500 12.800 ;
        RECT 32.800 12.100 33.200 12.500 ;
        RECT 31.900 11.600 32.300 12.000 ;
        RECT 31.800 5.300 32.400 5.900 ;
        RECT 32.900 5.400 33.100 12.100 ;
        RECT 34.400 11.900 35.000 12.500 ;
        RECT 35.700 12.000 35.900 16.400 ;
        RECT 39.000 14.800 41.400 15.900 ;
        RECT 36.500 12.100 36.900 12.500 ;
        RECT 37.300 12.400 37.900 13.000 ;
        RECT 35.600 11.600 36.000 12.000 ;
        RECT 36.500 9.600 36.700 12.100 ;
        RECT 35.700 9.400 36.700 9.600 ;
        RECT 35.700 5.800 35.900 9.400 ;
        RECT 37.500 7.700 37.700 12.400 ;
        RECT 38.100 11.900 38.700 12.500 ;
        RECT 38.900 8.100 41.200 9.300 ;
        RECT 37.500 7.500 39.100 7.700 ;
        RECT 35.600 5.500 36.000 5.800 ;
        RECT 34.400 5.400 36.000 5.500 ;
        RECT 32.700 4.800 33.300 5.400 ;
        RECT 34.400 5.300 35.800 5.400 ;
        RECT 34.400 4.900 35.000 5.300 ;
        RECT 33.700 4.500 34.100 4.900 ;
        RECT 36.400 4.800 37.000 5.400 ;
        RECT 37.500 4.900 37.700 7.500 ;
        RECT 38.100 4.900 38.700 5.500 ;
        RECT 37.400 4.500 37.800 4.900 ;
        RECT 31.100 4.300 34.000 4.500 ;
        RECT 33.800 3.800 34.000 4.300 ;
        RECT 38.400 3.800 38.600 4.900 ;
        RECT 33.800 3.600 38.600 3.800 ;
        RECT 29.100 1.600 31.500 2.700 ;
        RECT 38.900 0.400 39.100 7.500 ;
        RECT 41.800 4.500 42.000 18.000 ;
        RECT 44.300 17.600 44.900 18.200 ;
        RECT 45.100 18.100 45.700 18.700 ;
        RECT 45.300 17.000 45.500 18.100 ;
        RECT 47.100 18.000 47.700 18.600 ;
        RECT 48.000 17.600 48.600 18.200 ;
        RECT 48.800 18.100 49.500 18.700 ;
        RECT 54.200 18.200 54.600 18.500 ;
        RECT 52.500 18.100 54.600 18.200 ;
        RECT 42.700 16.800 45.500 17.000 ;
        RECT 42.700 12.000 42.900 16.800 ;
        RECT 49.100 16.600 49.300 18.100 ;
        RECT 46.400 16.400 49.300 16.600 ;
        RECT 52.500 18.000 54.500 18.100 ;
        RECT 45.700 13.000 46.200 13.200 ;
        RECT 44.500 12.900 46.200 13.000 ;
        RECT 44.400 12.800 46.200 12.900 ;
        RECT 44.400 12.500 44.800 12.800 ;
        RECT 45.700 12.700 46.200 12.800 ;
        RECT 43.500 12.100 43.900 12.500 ;
        RECT 42.600 11.600 43.000 12.000 ;
        RECT 42.500 5.300 43.100 5.900 ;
        RECT 43.600 5.400 43.800 12.100 ;
        RECT 45.100 11.900 45.700 12.500 ;
        RECT 46.400 12.000 46.600 16.400 ;
        RECT 49.700 14.800 52.100 15.900 ;
        RECT 47.200 12.100 47.600 12.500 ;
        RECT 48.000 12.400 48.600 13.000 ;
        RECT 46.300 11.600 46.700 12.000 ;
        RECT 47.200 9.600 47.400 12.100 ;
        RECT 46.400 9.400 47.400 9.600 ;
        RECT 46.400 5.800 46.600 9.400 ;
        RECT 48.200 7.700 48.400 12.400 ;
        RECT 48.800 11.900 49.400 12.500 ;
        RECT 49.300 8.100 51.600 9.300 ;
        RECT 48.200 7.500 49.800 7.700 ;
        RECT 46.300 5.500 46.700 5.800 ;
        RECT 45.100 5.400 46.700 5.500 ;
        RECT 43.400 4.800 44.000 5.400 ;
        RECT 45.100 5.300 46.500 5.400 ;
        RECT 45.100 4.900 45.700 5.300 ;
        RECT 44.400 4.500 44.800 4.900 ;
        RECT 47.100 4.800 47.700 5.400 ;
        RECT 48.200 4.900 48.400 7.500 ;
        RECT 48.800 4.900 49.400 5.500 ;
        RECT 48.100 4.500 48.500 4.900 ;
        RECT 41.800 4.300 44.700 4.500 ;
        RECT 44.500 3.800 44.700 4.300 ;
        RECT 49.100 3.800 49.300 4.900 ;
        RECT 44.500 3.600 49.300 3.800 ;
        RECT 39.800 1.600 42.200 2.700 ;
        RECT 49.600 0.400 49.800 7.500 ;
        RECT 52.500 4.500 52.700 18.000 ;
        RECT 55.000 17.600 55.600 18.200 ;
        RECT 55.800 18.100 56.400 18.700 ;
        RECT 56.000 17.000 56.200 18.100 ;
        RECT 57.800 18.000 58.400 18.600 ;
        RECT 58.700 17.600 59.300 18.200 ;
        RECT 59.500 18.100 60.200 18.700 ;
        RECT 64.900 18.200 65.300 18.500 ;
        RECT 63.200 18.100 65.300 18.200 ;
        RECT 53.400 16.800 56.200 17.000 ;
        RECT 53.400 12.000 53.600 16.800 ;
        RECT 59.800 16.600 60.000 18.100 ;
        RECT 57.100 16.400 60.000 16.600 ;
        RECT 63.200 18.000 65.200 18.100 ;
        RECT 56.400 13.000 56.900 13.200 ;
        RECT 55.200 12.900 56.900 13.000 ;
        RECT 55.100 12.800 56.900 12.900 ;
        RECT 55.100 12.500 55.500 12.800 ;
        RECT 56.400 12.700 56.900 12.800 ;
        RECT 54.200 12.100 54.600 12.500 ;
        RECT 53.300 11.600 53.700 12.000 ;
        RECT 53.200 5.300 53.800 5.900 ;
        RECT 54.300 5.400 54.500 12.100 ;
        RECT 55.800 11.900 56.400 12.500 ;
        RECT 57.100 12.000 57.300 16.400 ;
        RECT 60.400 14.800 62.800 15.900 ;
        RECT 57.900 12.100 58.300 12.500 ;
        RECT 58.700 12.400 59.300 13.000 ;
        RECT 57.000 11.600 57.400 12.000 ;
        RECT 57.900 9.600 58.100 12.100 ;
        RECT 57.100 9.400 58.100 9.600 ;
        RECT 57.100 5.800 57.300 9.400 ;
        RECT 58.900 7.700 59.100 12.400 ;
        RECT 59.500 11.900 60.100 12.500 ;
        RECT 59.900 8.100 62.200 9.300 ;
        RECT 58.900 7.500 60.500 7.700 ;
        RECT 57.000 5.500 57.400 5.800 ;
        RECT 55.800 5.400 57.400 5.500 ;
        RECT 54.100 4.800 54.700 5.400 ;
        RECT 55.800 5.300 57.200 5.400 ;
        RECT 55.800 4.900 56.400 5.300 ;
        RECT 55.100 4.500 55.500 4.900 ;
        RECT 57.800 4.800 58.400 5.400 ;
        RECT 58.900 4.900 59.100 7.500 ;
        RECT 59.500 4.900 60.100 5.500 ;
        RECT 58.800 4.500 59.200 4.900 ;
        RECT 52.500 4.300 55.400 4.500 ;
        RECT 55.200 3.800 55.400 4.300 ;
        RECT 59.800 3.800 60.000 4.900 ;
        RECT 55.200 3.600 60.000 3.800 ;
        RECT 51.000 1.600 53.400 2.700 ;
        RECT 53.750 0.400 54.250 0.450 ;
        RECT 60.300 0.400 60.500 7.500 ;
        RECT 63.200 4.500 63.400 18.000 ;
        RECT 65.700 17.600 66.300 18.200 ;
        RECT 66.500 18.100 67.100 18.700 ;
        RECT 66.700 17.000 66.900 18.100 ;
        RECT 68.500 18.000 69.100 18.600 ;
        RECT 69.400 17.600 70.000 18.200 ;
        RECT 70.200 18.100 70.900 18.700 ;
        RECT 75.600 18.200 76.000 18.500 ;
        RECT 73.900 18.100 76.000 18.200 ;
        RECT 64.100 16.800 66.900 17.000 ;
        RECT 64.100 12.000 64.300 16.800 ;
        RECT 70.500 16.600 70.700 18.100 ;
        RECT 67.800 16.400 70.700 16.600 ;
        RECT 73.900 18.000 75.900 18.100 ;
        RECT 67.100 13.000 67.600 13.200 ;
        RECT 65.900 12.900 67.600 13.000 ;
        RECT 65.800 12.800 67.600 12.900 ;
        RECT 65.800 12.500 66.200 12.800 ;
        RECT 67.100 12.700 67.600 12.800 ;
        RECT 64.900 12.100 65.300 12.500 ;
        RECT 64.000 11.600 64.400 12.000 ;
        RECT 63.900 5.300 64.500 5.900 ;
        RECT 65.000 5.400 65.200 12.100 ;
        RECT 66.500 11.900 67.100 12.500 ;
        RECT 67.800 12.000 68.000 16.400 ;
        RECT 71.100 14.800 73.500 15.900 ;
        RECT 68.600 12.100 69.000 12.500 ;
        RECT 69.400 12.400 70.000 13.000 ;
        RECT 67.700 11.600 68.100 12.000 ;
        RECT 68.600 9.600 68.800 12.100 ;
        RECT 67.800 9.400 68.800 9.600 ;
        RECT 67.800 5.800 68.000 9.400 ;
        RECT 69.600 7.700 69.800 12.400 ;
        RECT 70.200 11.900 70.800 12.500 ;
        RECT 70.700 8.100 73.000 9.300 ;
        RECT 69.600 7.500 71.400 7.700 ;
        RECT 67.700 5.500 68.100 5.800 ;
        RECT 66.500 5.400 68.100 5.500 ;
        RECT 64.800 4.800 65.400 5.400 ;
        RECT 66.500 5.300 67.900 5.400 ;
        RECT 66.500 4.900 67.100 5.300 ;
        RECT 65.800 4.500 66.200 4.900 ;
        RECT 68.500 4.800 69.100 5.400 ;
        RECT 69.600 4.900 69.800 7.500 ;
        RECT 70.200 4.900 70.800 5.500 ;
        RECT 69.500 4.500 69.900 4.900 ;
        RECT 63.200 4.300 66.100 4.500 ;
        RECT 65.900 3.800 66.100 4.300 ;
        RECT 70.500 3.800 70.700 4.900 ;
        RECT 65.900 3.600 70.700 3.800 ;
        RECT 61.500 1.600 63.900 2.700 ;
        RECT 71.200 0.650 71.400 7.500 ;
        RECT 73.900 4.500 74.100 18.000 ;
        RECT 76.400 17.600 77.000 18.200 ;
        RECT 77.200 18.100 77.800 18.700 ;
        RECT 77.400 17.000 77.600 18.100 ;
        RECT 79.200 18.000 79.800 18.600 ;
        RECT 80.100 17.600 80.700 18.200 ;
        RECT 80.900 18.100 81.600 18.700 ;
        RECT 74.800 16.800 77.600 17.000 ;
        RECT 74.800 12.000 75.000 16.800 ;
        RECT 81.200 16.600 81.400 18.100 ;
        RECT 78.500 16.400 81.400 16.600 ;
        RECT 77.800 13.000 78.300 13.200 ;
        RECT 76.600 12.900 78.300 13.000 ;
        RECT 76.500 12.800 78.300 12.900 ;
        RECT 76.500 12.500 76.900 12.800 ;
        RECT 77.800 12.700 78.300 12.800 ;
        RECT 75.600 12.100 76.000 12.500 ;
        RECT 74.700 11.600 75.100 12.000 ;
        RECT 74.600 5.300 75.200 5.900 ;
        RECT 75.700 5.400 75.900 12.100 ;
        RECT 77.200 11.900 77.800 12.500 ;
        RECT 78.500 12.000 78.700 16.400 ;
        RECT 79.300 12.100 79.700 12.500 ;
        RECT 80.100 12.400 80.700 13.000 ;
        RECT 78.400 11.600 78.800 12.000 ;
        RECT 79.300 9.600 79.500 12.100 ;
        RECT 78.500 9.400 79.500 9.600 ;
        RECT 78.500 5.800 78.700 9.400 ;
        RECT 80.300 7.700 80.500 12.400 ;
        RECT 80.900 11.900 81.500 12.500 ;
        RECT 80.300 7.500 82.000 7.700 ;
        RECT 78.400 5.500 78.800 5.800 ;
        RECT 77.200 5.400 78.800 5.500 ;
        RECT 75.500 4.800 76.100 5.400 ;
        RECT 77.200 5.300 78.600 5.400 ;
        RECT 77.200 4.900 77.800 5.300 ;
        RECT 76.500 4.500 76.900 4.900 ;
        RECT 79.200 4.800 79.800 5.400 ;
        RECT 80.300 4.900 80.500 7.500 ;
        RECT 80.900 4.900 81.500 5.500 ;
        RECT 80.200 4.500 80.600 4.900 ;
        RECT 73.900 4.300 76.800 4.500 ;
        RECT 76.600 3.800 76.800 4.300 ;
        RECT 81.200 3.800 81.400 4.900 ;
        RECT 76.600 3.600 81.400 3.800 ;
        RECT 72.300 1.600 74.700 2.700 ;
        RECT 81.800 0.650 82.000 7.500 ;
        RECT 71.100 0.450 107.550 0.650 ;
        RECT 69.850 0.400 107.550 0.450 ;
        RECT 9.100 0.200 107.550 0.400 ;
        RECT 16.900 0.000 17.500 0.200 ;
        RECT 14.360 -31.550 21.760 -30.600 ;
        RECT 29.800 -32.150 31.000 -30.850 ;
        RECT 35.650 -32.450 36.850 -31.150 ;
        RECT 41.450 -32.250 42.650 -30.950 ;
        RECT 23.100 -33.950 23.800 -33.250 ;
        RECT 53.750 -35.450 54.250 0.200 ;
        RECT 69.850 -0.900 107.550 0.200 ;
        RECT 63.010 -28.300 74.360 -27.200 ;
        RECT 75.650 -28.800 76.050 -28.700 ;
        RECT 66.850 -29.000 76.050 -28.800 ;
        RECT 66.850 -29.200 67.050 -29.000 ;
        RECT 75.650 -29.100 76.050 -29.000 ;
        RECT 66.750 -29.600 67.150 -29.200 ;
        RECT 83.000 -33.900 84.700 -32.300 ;
        RECT 54.900 -34.550 57.600 -34.100 ;
        RECT 20.800 -36.250 21.500 -35.550 ;
        RECT 53.750 -35.950 54.400 -35.450 ;
        RECT 54.900 -35.950 55.400 -34.550 ;
        RECT 71.950 -34.700 72.450 -34.200 ;
        RECT 73.150 -34.800 73.850 -34.100 ;
        RECT 69.050 -34.900 69.450 -34.800 ;
        RECT 64.850 -35.100 69.450 -34.900 ;
        RECT 64.750 -35.500 65.150 -35.100 ;
        RECT 69.050 -35.200 69.450 -35.100 ;
        RECT 70.750 -35.200 71.150 -34.800 ;
        RECT 76.050 -35.100 77.600 -34.600 ;
        RECT 18.800 -38.250 19.500 -37.550 ;
        RECT 34.850 -39.100 38.750 -38.200 ;
        RECT 42.950 -39.300 44.150 -38.000 ;
        RECT 45.850 -38.550 46.550 -37.850 ;
        RECT 51.450 -38.150 53.050 -36.100 ;
        RECT 53.900 -36.950 54.350 -35.950 ;
        RECT 66.450 -36.300 66.950 -35.800 ;
        RECT 53.900 -37.450 58.250 -36.950 ;
        RECT 57.800 -38.250 58.250 -37.450 ;
        RECT 66.950 -37.400 67.350 -37.300 ;
        RECT 70.850 -37.400 71.050 -35.200 ;
        RECT 66.950 -37.600 71.050 -37.400 ;
        RECT 66.950 -37.700 67.350 -37.600 ;
        RECT 77.150 -37.800 77.600 -35.100 ;
        RECT 83.000 -36.700 84.700 -35.100 ;
        RECT 77.150 -38.300 79.550 -37.800 ;
        RECT 77.150 -38.600 77.650 -38.300 ;
        RECT 62.450 -39.100 77.650 -38.600 ;
        RECT 83.000 -39.250 84.700 -37.650 ;
        RECT 5.150 -40.200 5.850 -40.100 ;
        RECT 5.150 -40.700 16.250 -40.200 ;
        RECT 5.150 -40.800 5.850 -40.700 ;
        RECT 8.550 -42.500 10.100 -41.500 ;
        RECT 11.400 -42.800 12.600 -41.500 ;
        RECT 12.850 -44.050 13.550 -43.350 ;
        RECT 15.700 -43.950 16.250 -40.700 ;
        RECT 16.700 -40.950 17.400 -40.250 ;
        RECT 42.100 -41.350 43.050 -40.250 ;
        RECT 23.850 -43.000 24.550 -42.300 ;
        RECT 41.550 -42.950 42.150 -42.250 ;
        RECT 53.200 -42.400 54.400 -41.100 ;
        RECT 75.150 -42.400 75.650 -39.900 ;
        RECT 78.950 -40.400 80.000 -39.950 ;
        RECT 58.300 -42.900 75.650 -42.400 ;
        RECT 45.750 -43.750 51.050 -43.050 ;
        RECT 79.600 -43.400 80.000 -40.400 ;
        RECT 83.000 -42.300 84.700 -40.700 ;
        RECT 15.700 -44.450 24.450 -43.950 ;
        RECT 35.100 -44.300 35.600 -43.850 ;
        RECT 9.250 -46.550 9.900 -45.850 ;
        RECT 23.850 -46.700 24.450 -44.450 ;
        RECT 33.200 -44.800 35.600 -44.300 ;
        RECT 2.600 -48.200 3.800 -46.900 ;
        RECT 23.850 -47.400 24.550 -46.700 ;
        RECT 2.650 -52.100 3.850 -50.800 ;
        RECT 6.700 -51.050 8.000 -47.900 ;
        RECT 11.350 -49.100 12.550 -47.800 ;
        RECT 18.910 -49.050 23.610 -48.300 ;
        RECT 27.200 -49.250 30.600 -47.750 ;
        RECT 14.660 -51.150 23.660 -51.000 ;
        RECT 14.650 -51.950 23.660 -51.150 ;
        RECT 14.660 -52.000 23.660 -51.950 ;
        RECT 3.900 -55.400 5.050 -54.150 ;
        RECT 1.950 -58.750 3.150 -57.450 ;
        RECT 15.550 -58.050 15.950 -57.650 ;
        RECT 33.200 -58.200 33.750 -44.800 ;
        RECT 37.700 -45.650 38.200 -43.750 ;
        RECT 45.750 -45.650 46.350 -43.750 ;
        RECT 37.700 -46.200 46.350 -45.650 ;
        RECT 44.050 -47.850 46.250 -46.600 ;
        RECT 50.200 -49.200 51.050 -43.750 ;
        RECT 53.200 -44.850 54.400 -43.550 ;
        RECT 79.600 -43.800 80.950 -43.400 ;
        RECT 68.100 -46.500 69.100 -45.800 ;
        RECT 70.250 -46.500 71.250 -45.800 ;
        RECT 78.950 -46.400 79.450 -44.000 ;
        RECT 80.450 -45.850 80.950 -43.800 ;
        RECT 80.450 -46.400 80.950 -46.350 ;
        RECT 64.800 -47.750 69.160 -46.800 ;
        RECT 78.950 -46.850 80.950 -46.400 ;
        RECT 80.450 -48.650 81.000 -46.850 ;
        RECT 83.000 -47.300 84.700 -45.700 ;
        RECT 98.000 -49.200 99.200 -42.950 ;
        RECT 50.200 -49.850 99.200 -49.200 ;
        RECT 50.200 -49.900 51.050 -49.850 ;
        RECT 35.300 -52.000 38.300 -51.100 ;
        RECT 43.400 -52.200 46.800 -51.350 ;
        RECT 37.700 -54.800 47.000 -54.100 ;
        RECT 17.000 -59.900 17.300 -58.500 ;
        RECT 20.000 -59.900 20.300 -58.500 ;
        RECT 33.200 -58.700 35.500 -58.200 ;
        RECT 2.100 -61.850 3.300 -60.550 ;
        RECT 2.350 -65.200 3.550 -63.900 ;
        RECT 15.250 -64.850 15.800 -64.300 ;
        RECT 17.050 -66.050 17.250 -59.900 ;
        RECT 18.250 -64.850 18.800 -64.300 ;
        RECT 20.050 -66.050 20.250 -59.900 ;
        RECT 29.700 -60.550 30.300 -60.000 ;
        RECT 30.750 -60.850 31.550 -60.750 ;
        RECT 33.200 -60.850 33.750 -58.700 ;
        RECT 35.000 -59.050 35.500 -58.700 ;
        RECT 37.700 -59.250 38.200 -54.800 ;
        RECT 46.300 -55.500 47.000 -54.800 ;
        RECT 63.950 -55.000 65.350 -53.900 ;
        RECT 48.700 -58.150 49.900 -56.850 ;
        RECT 51.200 -57.900 61.950 -57.350 ;
        RECT 41.900 -60.400 42.750 -59.550 ;
        RECT 46.600 -60.550 47.300 -59.850 ;
        RECT 30.750 -61.350 33.750 -60.850 ;
        RECT 51.200 -61.100 51.800 -57.900 ;
        RECT 54.150 -59.800 56.850 -59.250 ;
        RECT 61.450 -59.900 61.950 -57.900 ;
        RECT 61.450 -60.450 62.400 -59.900 ;
        RECT 62.900 -60.500 63.700 -59.800 ;
        RECT 30.750 -61.500 31.550 -61.350 ;
        RECT 21.250 -64.850 21.800 -64.300 ;
        RECT 5.000 -67.150 6.000 -66.200 ;
        RECT 14.250 -67.050 23.800 -66.050 ;
        RECT 25.100 -68.550 27.050 -67.250 ;
        RECT 33.200 -69.200 33.750 -61.350 ;
        RECT 40.600 -61.650 51.800 -61.100 ;
        RECT 52.850 -62.050 54.050 -61.500 ;
        RECT 55.000 -62.450 55.600 -61.900 ;
        RECT 57.700 -62.300 58.250 -61.750 ;
        RECT 35.050 -64.750 38.550 -63.750 ;
        RECT 41.600 -64.300 42.150 -63.600 ;
        RECT 54.150 -64.600 56.850 -63.900 ;
        RECT 61.950 -64.850 63.500 -63.850 ;
        RECT 44.050 -68.950 44.950 -68.200 ;
        RECT 33.200 -69.700 35.500 -69.200 ;
        RECT 35.000 -70.050 35.500 -69.700 ;
        RECT 9.850 -72.600 13.550 -71.850 ;
        RECT 16.350 -73.200 17.050 -72.500 ;
        RECT 18.350 -73.200 19.050 -72.500 ;
        RECT 37.700 -73.700 38.200 -69.250 ;
        RECT 47.350 -69.850 47.850 -69.350 ;
        RECT 37.700 -74.200 47.800 -73.700 ;
        RECT 48.750 -74.050 49.950 -72.750 ;
        RECT 35.100 -77.500 38.500 -76.700 ;
        RECT 47.100 -77.150 47.800 -74.200 ;
        RECT 11.350 -81.500 12.050 -80.800 ;
        RECT 16.850 -81.500 17.550 -80.800 ;
        RECT 22.250 -81.500 22.950 -80.800 ;
        RECT 27.850 -81.500 28.550 -80.800 ;
        RECT 43.950 -81.450 47.550 -80.750 ;
        RECT 17.400 -83.750 23.550 -82.300 ;
      LAYER met2 ;
        RECT 12.600 34.500 14.900 35.700 ;
        RECT 21.000 34.500 23.300 35.700 ;
        RECT 32.700 34.500 35.000 35.700 ;
        RECT 42.100 34.500 44.400 35.700 ;
        RECT 53.900 34.500 56.200 35.700 ;
        RECT 64.400 34.500 66.700 35.700 ;
        RECT 17.700 29.700 20.100 30.800 ;
        RECT 28.400 29.700 30.800 30.800 ;
        RECT 39.100 29.700 41.500 30.800 ;
        RECT 49.800 29.700 52.200 30.800 ;
        RECT 60.500 29.700 62.900 30.800 ;
        RECT 71.200 29.700 73.600 30.800 ;
        RECT 4.800 26.200 5.400 26.800 ;
        RECT 13.400 26.200 14.000 26.800 ;
        RECT 24.100 26.200 24.700 26.800 ;
        RECT 34.800 26.200 35.400 26.800 ;
        RECT 45.500 26.200 46.100 26.800 ;
        RECT 56.200 26.200 56.800 26.800 ;
        RECT 66.900 26.200 67.500 26.800 ;
        RECT 77.600 26.200 78.200 26.800 ;
        RECT 18.000 21.300 20.300 22.500 ;
        RECT 28.700 21.300 31.000 22.500 ;
        RECT 39.400 21.300 41.700 22.500 ;
        RECT 50.100 21.300 52.400 22.500 ;
        RECT 60.800 21.300 63.100 22.500 ;
        RECT 71.500 21.300 73.800 22.500 ;
        RECT 3.600 18.000 4.200 18.200 ;
        RECT 6.400 18.000 7.000 18.600 ;
        RECT 3.600 17.800 6.700 18.000 ;
        RECT 3.600 17.600 4.200 17.800 ;
        RECT 7.300 17.600 7.900 18.200 ;
        RECT 12.200 18.000 12.800 18.200 ;
        RECT 15.000 18.000 15.600 18.600 ;
        RECT 12.200 17.800 15.300 18.000 ;
        RECT 12.200 17.600 12.800 17.800 ;
        RECT 15.900 17.600 16.500 18.200 ;
        RECT 22.900 18.000 23.500 18.200 ;
        RECT 25.700 18.000 26.300 18.600 ;
        RECT 22.900 17.800 26.000 18.000 ;
        RECT 22.900 17.600 23.500 17.800 ;
        RECT 26.600 17.600 27.200 18.200 ;
        RECT 33.600 18.000 34.200 18.200 ;
        RECT 36.400 18.000 37.000 18.600 ;
        RECT 33.600 17.800 36.700 18.000 ;
        RECT 33.600 17.600 34.200 17.800 ;
        RECT 37.300 17.600 37.900 18.200 ;
        RECT 44.300 18.000 44.900 18.200 ;
        RECT 47.100 18.000 47.700 18.600 ;
        RECT 44.300 17.800 47.400 18.000 ;
        RECT 44.300 17.600 44.900 17.800 ;
        RECT 48.000 17.600 48.600 18.200 ;
        RECT 55.000 18.000 55.600 18.200 ;
        RECT 57.800 18.000 58.400 18.600 ;
        RECT 55.000 17.800 58.100 18.000 ;
        RECT 55.000 17.600 55.600 17.800 ;
        RECT 58.700 17.600 59.300 18.200 ;
        RECT 65.700 18.000 66.300 18.200 ;
        RECT 68.500 18.000 69.100 18.600 ;
        RECT 65.700 17.800 68.800 18.000 ;
        RECT 65.700 17.600 66.300 17.800 ;
        RECT 69.400 17.600 70.000 18.200 ;
        RECT 76.400 18.000 77.000 18.200 ;
        RECT 79.200 18.000 79.800 18.600 ;
        RECT 76.400 17.800 79.500 18.000 ;
        RECT 76.400 17.600 77.000 17.800 ;
        RECT 80.100 17.600 80.700 18.200 ;
        RECT 3.800 16.300 4.000 17.600 ;
        RECT 3.800 16.100 4.800 16.300 ;
        RECT 4.600 12.500 4.800 16.100 ;
        RECT 7.500 16.200 7.700 17.600 ;
        RECT 12.400 16.300 12.600 17.600 ;
        RECT 7.500 16.000 8.500 16.200 ;
        RECT 12.400 16.100 13.400 16.300 ;
        RECT 5.000 13.100 5.500 13.200 ;
        RECT 5.000 13.000 7.700 13.100 ;
        RECT 5.000 12.800 7.900 13.000 ;
        RECT 5.000 12.700 5.500 12.800 ;
        RECT 4.400 11.900 5.000 12.500 ;
        RECT 7.300 12.400 7.900 12.800 ;
        RECT 8.300 12.500 8.500 16.000 ;
        RECT 13.200 12.500 13.400 16.100 ;
        RECT 16.100 16.200 16.300 17.600 ;
        RECT 23.100 16.300 23.300 17.600 ;
        RECT 16.100 16.000 17.100 16.200 ;
        RECT 23.100 16.100 24.100 16.300 ;
        RECT 13.600 13.100 14.100 13.200 ;
        RECT 13.600 13.000 16.300 13.100 ;
        RECT 13.600 12.800 16.500 13.000 ;
        RECT 13.600 12.700 14.100 12.800 ;
        RECT 8.100 11.900 8.700 12.500 ;
        RECT 13.000 11.900 13.600 12.500 ;
        RECT 15.900 12.400 16.500 12.800 ;
        RECT 16.900 12.500 17.100 16.000 ;
        RECT 17.600 14.800 20.000 15.900 ;
        RECT 23.900 12.500 24.100 16.100 ;
        RECT 26.800 16.200 27.000 17.600 ;
        RECT 33.800 16.300 34.000 17.600 ;
        RECT 26.800 16.000 27.800 16.200 ;
        RECT 33.800 16.100 34.800 16.300 ;
        RECT 24.300 13.100 24.800 13.200 ;
        RECT 24.300 13.000 27.000 13.100 ;
        RECT 24.300 12.800 27.200 13.000 ;
        RECT 24.300 12.700 24.800 12.800 ;
        RECT 16.700 11.900 17.300 12.500 ;
        RECT 23.700 11.900 24.300 12.500 ;
        RECT 26.600 12.400 27.200 12.800 ;
        RECT 27.600 12.500 27.800 16.000 ;
        RECT 28.300 14.800 30.700 15.900 ;
        RECT 34.600 12.500 34.800 16.100 ;
        RECT 37.500 16.200 37.700 17.600 ;
        RECT 44.500 16.300 44.700 17.600 ;
        RECT 37.500 16.000 38.500 16.200 ;
        RECT 44.500 16.100 45.500 16.300 ;
        RECT 35.000 13.100 35.500 13.200 ;
        RECT 35.000 13.000 37.700 13.100 ;
        RECT 35.000 12.800 37.900 13.000 ;
        RECT 35.000 12.700 35.500 12.800 ;
        RECT 27.400 11.900 28.000 12.500 ;
        RECT 34.400 11.900 35.000 12.500 ;
        RECT 37.300 12.400 37.900 12.800 ;
        RECT 38.300 12.500 38.500 16.000 ;
        RECT 39.000 14.800 41.400 15.900 ;
        RECT 45.300 12.500 45.500 16.100 ;
        RECT 48.200 16.200 48.400 17.600 ;
        RECT 55.200 16.300 55.400 17.600 ;
        RECT 48.200 16.000 49.200 16.200 ;
        RECT 55.200 16.100 56.200 16.300 ;
        RECT 45.700 13.100 46.200 13.200 ;
        RECT 45.700 13.000 48.400 13.100 ;
        RECT 45.700 12.800 48.600 13.000 ;
        RECT 45.700 12.700 46.200 12.800 ;
        RECT 38.100 11.900 38.700 12.500 ;
        RECT 45.100 11.900 45.700 12.500 ;
        RECT 48.000 12.400 48.600 12.800 ;
        RECT 49.000 12.500 49.200 16.000 ;
        RECT 49.700 14.800 52.100 15.900 ;
        RECT 56.000 12.500 56.200 16.100 ;
        RECT 58.900 16.200 59.100 17.600 ;
        RECT 65.900 16.300 66.100 17.600 ;
        RECT 58.900 16.000 59.900 16.200 ;
        RECT 65.900 16.100 66.900 16.300 ;
        RECT 56.400 13.100 56.900 13.200 ;
        RECT 56.400 13.000 59.100 13.100 ;
        RECT 56.400 12.800 59.300 13.000 ;
        RECT 56.400 12.700 56.900 12.800 ;
        RECT 48.800 11.900 49.400 12.500 ;
        RECT 55.800 11.900 56.400 12.500 ;
        RECT 58.700 12.400 59.300 12.800 ;
        RECT 59.700 12.500 59.900 16.000 ;
        RECT 60.400 14.800 62.800 15.900 ;
        RECT 66.700 12.500 66.900 16.100 ;
        RECT 69.600 16.200 69.800 17.600 ;
        RECT 76.600 16.300 76.800 17.600 ;
        RECT 69.600 16.000 70.600 16.200 ;
        RECT 76.600 16.100 77.600 16.300 ;
        RECT 67.100 13.100 67.600 13.200 ;
        RECT 67.100 13.000 69.800 13.100 ;
        RECT 67.100 12.800 70.000 13.000 ;
        RECT 67.100 12.700 67.600 12.800 ;
        RECT 59.500 11.900 60.100 12.500 ;
        RECT 66.500 11.900 67.100 12.500 ;
        RECT 69.400 12.400 70.000 12.800 ;
        RECT 70.400 12.500 70.600 16.000 ;
        RECT 71.100 14.800 73.500 15.900 ;
        RECT 77.400 12.500 77.600 16.100 ;
        RECT 80.300 16.200 80.500 17.600 ;
        RECT 80.300 16.000 81.300 16.200 ;
        RECT 77.800 13.100 78.300 13.200 ;
        RECT 77.800 13.000 80.500 13.100 ;
        RECT 77.800 12.800 80.700 13.000 ;
        RECT 77.800 12.700 78.300 12.800 ;
        RECT 70.200 11.900 70.800 12.500 ;
        RECT 77.200 11.900 77.800 12.500 ;
        RECT 80.100 12.400 80.700 12.800 ;
        RECT 81.100 12.500 81.300 16.000 ;
        RECT 80.900 11.900 81.500 12.500 ;
        RECT 4.600 10.600 4.800 11.900 ;
        RECT 13.200 10.600 13.400 11.900 ;
        RECT 23.900 10.600 24.100 11.900 ;
        RECT 34.600 10.600 34.800 11.900 ;
        RECT 45.300 10.600 45.500 11.900 ;
        RECT 56.000 10.600 56.200 11.900 ;
        RECT 66.700 10.600 66.900 11.900 ;
        RECT 77.400 10.600 77.600 11.900 ;
        RECT 2.000 10.400 4.800 10.600 ;
        RECT 10.600 10.400 13.400 10.600 ;
        RECT 21.300 10.400 24.100 10.600 ;
        RECT 32.000 10.400 34.800 10.600 ;
        RECT 42.700 10.400 45.500 10.600 ;
        RECT 53.400 10.400 56.200 10.600 ;
        RECT 64.100 10.400 66.900 10.600 ;
        RECT 74.800 10.400 77.600 10.600 ;
        RECT 2.000 5.900 2.200 10.400 ;
        RECT 10.600 5.900 10.800 10.400 ;
        RECT 17.400 8.100 19.700 9.300 ;
        RECT 21.300 5.900 21.500 10.400 ;
        RECT 28.000 8.100 30.300 9.300 ;
        RECT 32.000 5.900 32.200 10.400 ;
        RECT 38.900 8.100 41.200 9.300 ;
        RECT 42.700 5.900 42.900 10.400 ;
        RECT 49.300 8.100 51.600 9.300 ;
        RECT 53.400 5.900 53.600 10.400 ;
        RECT 59.900 8.100 62.200 9.300 ;
        RECT 64.100 5.900 64.300 10.400 ;
        RECT 70.700 8.100 73.000 9.300 ;
        RECT 74.800 5.900 75.000 10.400 ;
        RECT 1.800 5.300 2.400 5.900 ;
        RECT -0.300 5.000 0.600 5.200 ;
        RECT 2.700 5.000 3.300 5.400 ;
        RECT -0.300 4.800 3.300 5.000 ;
        RECT 6.400 4.800 7.000 5.400 ;
        RECT 10.400 5.300 11.000 5.900 ;
        RECT 11.300 5.000 11.900 5.400 ;
        RECT 8.900 4.800 11.900 5.000 ;
        RECT 15.000 4.800 15.600 5.400 ;
        RECT 21.100 5.300 21.700 5.900 ;
        RECT 22.000 5.000 22.600 5.400 ;
        RECT 19.900 4.800 22.600 5.000 ;
        RECT 25.700 4.800 26.300 5.400 ;
        RECT 31.800 5.300 32.400 5.900 ;
        RECT 32.700 5.000 33.300 5.400 ;
        RECT 30.600 4.800 33.300 5.000 ;
        RECT 36.400 4.800 37.000 5.400 ;
        RECT 42.500 5.300 43.100 5.900 ;
        RECT 43.400 5.000 44.000 5.400 ;
        RECT 41.300 4.800 44.000 5.000 ;
        RECT 47.100 4.800 47.700 5.400 ;
        RECT 53.200 5.300 53.800 5.900 ;
        RECT 54.100 5.000 54.700 5.400 ;
        RECT 52.000 4.800 54.700 5.000 ;
        RECT 57.800 4.800 58.400 5.400 ;
        RECT 63.900 5.300 64.500 5.900 ;
        RECT 64.800 5.000 65.400 5.400 ;
        RECT 62.700 4.800 65.400 5.000 ;
        RECT 68.500 4.800 69.100 5.400 ;
        RECT 74.600 5.300 75.200 5.900 ;
        RECT 75.500 5.000 76.100 5.400 ;
        RECT 73.400 4.800 76.100 5.000 ;
        RECT 79.200 4.800 79.800 5.400 ;
        RECT -0.300 4.300 0.600 4.800 ;
        RECT 1.200 3.200 1.400 4.800 ;
        RECT 8.900 3.200 9.100 4.800 ;
        RECT 19.900 3.200 20.100 4.800 ;
        RECT 30.600 3.200 30.800 4.800 ;
        RECT 41.300 3.200 41.500 4.800 ;
        RECT 52.000 3.200 52.200 4.800 ;
        RECT 62.700 3.200 62.900 4.800 ;
        RECT 73.400 3.200 73.600 4.800 ;
        RECT 1.200 3.000 73.600 3.200 ;
        RECT 9.700 1.600 12.100 2.700 ;
        RECT 18.500 1.600 20.900 2.700 ;
        RECT 29.100 1.600 31.500 2.700 ;
        RECT 39.800 1.600 42.200 2.700 ;
        RECT 51.000 1.600 53.400 2.700 ;
        RECT 61.500 1.600 63.900 2.700 ;
        RECT 72.300 1.600 74.700 2.700 ;
        RECT 69.850 -0.900 71.400 0.450 ;
        RECT 63.010 -28.300 74.360 -27.200 ;
        RECT 14.360 -30.800 21.760 -30.600 ;
        RECT 14.350 -31.550 21.760 -30.800 ;
        RECT 14.350 -31.750 21.750 -31.550 ;
        RECT 29.800 -32.150 31.000 -30.850 ;
        RECT 35.650 -32.450 36.850 -31.150 ;
        RECT 41.450 -32.250 42.650 -30.950 ;
        RECT 23.100 -33.950 23.800 -33.250 ;
        RECT 83.000 -33.900 84.700 -32.300 ;
        RECT 73.150 -34.200 73.850 -34.100 ;
        RECT 27.800 -35.250 63.650 -34.550 ;
        RECT 71.950 -34.700 72.450 -34.200 ;
        RECT 73.150 -34.700 74.100 -34.200 ;
        RECT 20.800 -36.250 21.500 -35.550 ;
        RECT 23.700 -37.050 48.200 -36.450 ;
        RECT 18.800 -38.250 19.500 -37.550 ;
        RECT 16.700 -40.950 17.400 -40.250 ;
        RECT 8.550 -42.500 10.100 -41.500 ;
        RECT 11.400 -42.800 12.600 -41.500 ;
        RECT 23.850 -43.000 24.550 -37.050 ;
        RECT 47.750 -37.850 48.200 -37.050 ;
        RECT 34.850 -39.100 38.750 -38.200 ;
        RECT 42.950 -39.300 44.150 -38.000 ;
        RECT 45.850 -38.550 48.200 -37.850 ;
        RECT 51.450 -38.150 53.050 -36.100 ;
        RECT 42.100 -41.350 43.050 -40.250 ;
        RECT 41.550 -42.950 42.150 -42.250 ;
        RECT 12.850 -44.050 13.550 -43.350 ;
        RECT 45.750 -43.750 46.350 -43.050 ;
        RECT 9.250 -45.950 9.900 -45.850 ;
        RECT 9.250 -46.450 11.000 -45.950 ;
        RECT 9.250 -46.550 9.900 -46.450 ;
        RECT 2.600 -48.200 3.800 -46.900 ;
        RECT 23.850 -47.400 24.550 -46.700 ;
        RECT 2.650 -52.100 3.850 -50.800 ;
        RECT 6.700 -51.050 8.000 -47.900 ;
        RECT 11.350 -49.100 12.550 -47.800 ;
        RECT 18.900 -49.150 23.650 -48.300 ;
        RECT 27.200 -49.250 30.600 -47.750 ;
        RECT 44.050 -47.850 46.250 -46.600 ;
        RECT 14.660 -52.000 23.660 -51.000 ;
        RECT 35.300 -52.000 38.300 -51.100 ;
        RECT 43.400 -52.200 46.800 -51.350 ;
        RECT 3.900 -55.400 5.050 -54.150 ;
        RECT 46.300 -55.500 47.000 -54.800 ;
        RECT 1.950 -58.750 3.150 -57.450 ;
        RECT 15.550 -58.050 30.300 -57.650 ;
        RECT 29.700 -60.550 30.300 -58.050 ;
        RECT 41.900 -60.400 42.750 -59.550 ;
        RECT 47.750 -59.850 48.200 -38.550 ;
        RECT 48.900 -54.600 49.800 -38.700 ;
        RECT 53.200 -42.400 54.400 -41.100 ;
        RECT 53.200 -44.850 54.400 -43.550 ;
        RECT 53.950 -51.550 58.750 -50.550 ;
        RECT 62.700 -50.900 63.650 -35.250 ;
        RECT 66.450 -35.900 66.950 -35.800 ;
        RECT 72.050 -35.900 72.350 -34.700 ;
        RECT 73.150 -34.800 73.850 -34.700 ;
        RECT 66.450 -36.200 72.350 -35.900 ;
        RECT 66.450 -36.300 66.950 -36.200 ;
        RECT 83.000 -36.700 84.700 -35.100 ;
        RECT 83.000 -39.250 84.700 -37.650 ;
        RECT 83.000 -42.300 84.700 -40.700 ;
        RECT 68.100 -46.500 69.100 -45.800 ;
        RECT 70.250 -46.500 71.250 -45.800 ;
        RECT 64.800 -47.750 69.160 -46.800 ;
        RECT 80.450 -48.650 81.000 -46.850 ;
        RECT 83.000 -47.300 84.700 -45.700 ;
        RECT 48.700 -58.150 49.900 -56.850 ;
        RECT 54.150 -59.800 56.900 -51.550 ;
        RECT 60.250 -51.600 63.650 -50.900 ;
        RECT 46.600 -60.550 48.200 -59.850 ;
        RECT 60.250 -60.300 60.950 -51.600 ;
        RECT 63.950 -55.000 65.350 -53.900 ;
        RECT 2.100 -61.850 3.300 -60.550 ;
        RECT 2.350 -65.200 3.550 -63.900 ;
        RECT 9.650 -64.450 15.800 -64.300 ;
        RECT 18.250 -64.450 18.800 -64.300 ;
        RECT 21.250 -64.450 21.800 -64.300 ;
        RECT 9.650 -64.700 21.800 -64.450 ;
        RECT 9.650 -64.850 15.800 -64.700 ;
        RECT 18.250 -64.850 18.800 -64.700 ;
        RECT 21.250 -64.850 21.800 -64.700 ;
        RECT 35.050 -64.750 38.550 -63.750 ;
        RECT 41.600 -64.300 42.150 -63.600 ;
        RECT 5.000 -67.150 6.000 -66.200 ;
        RECT 9.650 -69.700 10.200 -64.850 ;
        RECT 15.010 -67.050 23.110 -66.100 ;
        RECT 25.100 -68.550 27.050 -67.250 ;
        RECT 44.050 -68.950 44.950 -68.200 ;
        RECT 47.750 -68.700 48.200 -60.550 ;
        RECT 55.050 -60.850 60.950 -60.300 ;
        RECT 62.900 -60.500 63.700 -59.800 ;
        RECT 52.850 -62.050 54.050 -61.500 ;
        RECT 55.050 -61.900 55.600 -60.850 ;
        RECT 55.000 -62.450 55.600 -61.900 ;
        RECT 57.700 -62.300 58.250 -61.750 ;
        RECT 55.050 -62.650 55.600 -62.450 ;
        RECT 51.450 -63.200 55.600 -62.650 ;
        RECT 54.150 -64.600 56.850 -63.900 ;
        RECT 61.950 -64.850 63.500 -63.850 ;
        RECT 47.350 -69.150 48.200 -68.700 ;
        RECT 12.300 -69.700 12.850 -69.600 ;
        RECT 16.350 -69.700 17.050 -69.650 ;
        RECT 9.650 -70.300 17.050 -69.700 ;
        RECT 47.350 -69.850 47.850 -69.150 ;
        RECT 9.850 -72.600 13.550 -71.850 ;
        RECT 16.350 -73.200 17.050 -70.300 ;
        RECT 18.350 -73.200 19.050 -72.500 ;
        RECT 48.750 -74.050 49.950 -72.750 ;
        RECT 35.100 -77.500 38.500 -76.700 ;
        RECT 47.100 -77.150 47.800 -76.450 ;
        RECT 11.350 -81.000 12.050 -80.800 ;
        RECT 16.850 -81.000 17.550 -80.800 ;
        RECT 22.250 -81.000 22.950 -80.800 ;
        RECT 27.850 -81.000 28.550 -80.800 ;
        RECT 11.350 -81.300 12.750 -81.000 ;
        RECT 16.850 -81.300 18.250 -81.000 ;
        RECT 22.250 -81.300 23.650 -81.000 ;
        RECT 27.850 -81.300 29.250 -81.000 ;
        RECT 11.350 -81.500 12.050 -81.300 ;
        RECT 16.850 -81.500 17.550 -81.300 ;
        RECT 22.250 -81.500 22.950 -81.300 ;
        RECT 27.850 -81.500 28.550 -81.300 ;
        RECT 43.950 -81.450 47.550 -80.750 ;
        RECT 17.350 -83.750 23.550 -82.300 ;
      LAYER met3 ;
        RECT 12.600 34.500 14.900 35.700 ;
        RECT 21.000 34.500 23.300 35.700 ;
        RECT 32.700 34.500 35.000 35.700 ;
        RECT 42.100 34.500 44.400 35.700 ;
        RECT 53.900 34.500 56.200 35.700 ;
        RECT 64.400 34.500 66.700 35.700 ;
        RECT 17.700 29.700 20.100 30.800 ;
        RECT 28.400 29.700 30.800 30.800 ;
        RECT 39.100 29.700 41.500 30.800 ;
        RECT 49.800 29.700 52.200 30.800 ;
        RECT 60.500 29.700 62.900 30.800 ;
        RECT 71.200 29.700 73.600 30.800 ;
        RECT 4.800 26.200 5.400 26.800 ;
        RECT 13.400 26.200 14.000 26.800 ;
        RECT 24.100 26.200 24.700 26.800 ;
        RECT 34.800 26.200 35.400 26.800 ;
        RECT 45.500 26.200 46.100 26.800 ;
        RECT 56.200 26.200 56.800 26.800 ;
        RECT 66.900 26.200 67.500 26.800 ;
        RECT 77.600 26.200 78.200 26.800 ;
        RECT 5.000 5.200 5.300 26.200 ;
        RECT 6.400 5.200 7.000 5.400 ;
        RECT -0.300 -17.500 0.600 5.200 ;
        RECT 5.000 4.900 7.000 5.200 ;
        RECT 13.600 5.200 13.900 26.200 ;
        RECT 18.000 21.300 20.300 22.500 ;
        RECT 17.600 15.900 19.900 16.000 ;
        RECT 17.600 14.800 20.000 15.900 ;
        RECT 17.400 8.100 19.700 9.300 ;
        RECT 15.000 5.200 15.600 5.400 ;
        RECT 13.600 4.900 15.600 5.200 ;
        RECT 24.300 5.200 24.600 26.200 ;
        RECT 28.700 21.300 31.000 22.500 ;
        RECT 28.300 14.800 30.700 15.900 ;
        RECT 28.000 8.100 30.300 9.300 ;
        RECT 25.700 5.200 26.300 5.400 ;
        RECT 24.300 4.900 26.300 5.200 ;
        RECT 35.000 5.200 35.300 26.200 ;
        RECT 39.400 21.300 41.700 22.500 ;
        RECT 39.000 14.800 41.400 15.900 ;
        RECT 38.900 8.100 41.200 9.300 ;
        RECT 36.400 5.200 37.000 5.400 ;
        RECT 35.000 4.900 37.000 5.200 ;
        RECT 45.700 5.200 46.000 26.200 ;
        RECT 50.100 21.300 52.400 22.500 ;
        RECT 49.700 14.800 52.100 15.900 ;
        RECT 49.300 8.100 51.600 9.300 ;
        RECT 47.100 5.200 47.700 5.400 ;
        RECT 45.700 4.900 47.700 5.200 ;
        RECT 56.400 5.200 56.700 26.200 ;
        RECT 60.800 21.300 63.100 22.500 ;
        RECT 60.400 14.800 62.800 15.900 ;
        RECT 59.900 8.100 62.200 9.300 ;
        RECT 57.800 5.200 58.400 5.400 ;
        RECT 56.400 4.900 58.400 5.200 ;
        RECT 67.100 5.200 67.400 26.200 ;
        RECT 71.500 21.300 73.800 22.500 ;
        RECT 71.100 15.900 73.400 16.000 ;
        RECT 71.100 14.800 73.500 15.900 ;
        RECT 70.700 8.100 73.000 9.300 ;
        RECT 68.500 5.200 69.100 5.400 ;
        RECT 67.100 4.900 69.100 5.200 ;
        RECT 77.800 5.200 78.100 26.200 ;
        RECT 79.200 5.200 79.800 5.400 ;
        RECT 77.800 4.900 79.800 5.200 ;
        RECT 6.400 4.800 7.000 4.900 ;
        RECT 15.000 4.800 15.600 4.900 ;
        RECT 25.700 4.800 26.300 4.900 ;
        RECT 36.400 4.800 37.000 4.900 ;
        RECT 47.100 4.800 47.700 4.900 ;
        RECT 57.800 4.800 58.400 4.900 ;
        RECT 68.500 4.800 69.100 4.900 ;
        RECT 79.200 4.800 79.800 4.900 ;
        RECT 18.500 2.700 20.800 2.800 ;
        RECT 72.300 2.700 74.600 2.800 ;
        RECT 9.700 1.600 12.100 2.700 ;
        RECT 18.500 1.600 20.900 2.700 ;
        RECT 29.100 1.600 31.500 2.700 ;
        RECT 39.800 1.600 42.200 2.700 ;
        RECT 51.000 1.600 53.400 2.700 ;
        RECT 61.500 1.600 63.900 2.700 ;
        RECT 72.300 1.600 74.700 2.700 ;
        RECT 69.850 -1.250 87.050 0.600 ;
        RECT -0.300 -18.350 49.800 -17.500 ;
        RECT 14.350 -31.750 21.750 -30.800 ;
        RECT 29.800 -32.150 31.000 -30.850 ;
        RECT 35.650 -32.450 36.850 -31.150 ;
        RECT 41.450 -32.250 42.650 -30.950 ;
        RECT 10.500 -35.250 30.000 -34.550 ;
        RECT 8.550 -42.500 10.100 -41.500 ;
        RECT 10.500 -46.450 11.000 -35.250 ;
        RECT 34.850 -39.100 38.750 -38.200 ;
        RECT 42.950 -39.300 44.150 -38.000 ;
        RECT 48.900 -39.200 49.800 -18.350 ;
        RECT 63.010 -28.300 84.750 -27.200 ;
        RECT 73.150 -34.800 73.850 -34.100 ;
        RECT 51.100 -37.900 53.400 -36.100 ;
        RECT 51.100 -38.150 53.050 -37.900 ;
        RECT 42.100 -41.350 43.050 -40.250 ;
        RECT 11.400 -42.800 12.600 -41.500 ;
        RECT 2.600 -48.200 3.800 -46.900 ;
        RECT 2.650 -52.100 3.850 -50.800 ;
        RECT 6.700 -51.050 8.000 -47.900 ;
        RECT 11.350 -49.100 12.550 -47.800 ;
        RECT 27.200 -48.000 32.700 -47.750 ;
        RECT 25.900 -48.200 32.700 -48.000 ;
        RECT 21.450 -48.300 32.700 -48.200 ;
        RECT 18.900 -49.100 32.700 -48.300 ;
        RECT 18.000 -49.250 32.700 -49.100 ;
        RECT 18.000 -51.000 22.800 -49.250 ;
        RECT 31.600 -51.000 32.700 -49.250 ;
        RECT 44.050 -50.550 46.250 -46.600 ;
        RECT 51.100 -46.800 52.300 -38.150 ;
        RECT 53.200 -42.400 54.400 -41.100 ;
        RECT 53.200 -44.850 54.400 -43.550 ;
        RECT 68.100 -46.500 69.100 -45.800 ;
        RECT 70.250 -46.500 71.250 -45.800 ;
        RECT 51.100 -47.750 70.350 -46.800 ;
        RECT 63.950 -50.550 65.000 -47.750 ;
        RECT 80.450 -48.000 81.000 -46.850 ;
        RECT 83.000 -47.300 84.700 -28.300 ;
        RECT 85.500 -48.000 87.050 -1.250 ;
        RECT 80.450 -48.650 87.050 -48.000 ;
        RECT 44.050 -50.600 65.000 -50.550 ;
        RECT 39.850 -51.000 65.000 -50.600 ;
        RECT 14.660 -51.050 23.660 -51.000 ;
        RECT 6.700 -51.950 23.660 -51.050 ;
        RECT 14.660 -52.000 23.660 -51.950 ;
        RECT 31.600 -51.550 65.000 -51.000 ;
        RECT 31.600 -51.650 46.850 -51.550 ;
        RECT 31.600 -52.100 41.200 -51.650 ;
        RECT 36.250 -52.150 41.200 -52.100 ;
        RECT 43.400 -52.200 46.850 -51.650 ;
        RECT 63.950 -53.900 65.000 -51.550 ;
        RECT -2.950 -55.400 5.050 -54.150 ;
        RECT 48.900 -54.600 58.800 -53.900 ;
        RECT 1.950 -58.750 3.150 -57.450 ;
        RECT 2.100 -61.850 3.300 -60.550 ;
        RECT 4.000 -61.350 5.050 -55.400 ;
        RECT 48.700 -58.150 49.900 -56.850 ;
        RECT 41.900 -60.400 42.750 -59.550 ;
        RECT 54.150 -59.800 56.850 -59.250 ;
        RECT 4.000 -62.150 54.050 -61.350 ;
        RECT 58.150 -61.750 58.800 -54.600 ;
        RECT 63.950 -55.000 65.350 -53.900 ;
        RECT 85.500 -59.550 87.050 -48.650 ;
        RECT 63.600 -59.600 87.050 -59.550 ;
        RECT 62.900 -60.700 87.050 -59.600 ;
        RECT 85.500 -60.750 87.050 -60.700 ;
        RECT 57.700 -62.300 58.800 -61.750 ;
        RECT 2.350 -65.200 3.550 -63.900 ;
        RECT 35.050 -64.750 38.550 -63.750 ;
        RECT 41.600 -64.300 42.150 -63.600 ;
        RECT 5.000 -68.600 6.000 -66.200 ;
        RECT 15.010 -67.050 23.110 -66.100 ;
        RECT 25.100 -68.550 27.050 -67.250 ;
        RECT 5.000 -69.300 20.200 -68.600 ;
        RECT 44.050 -68.950 44.950 -68.200 ;
        RECT 9.850 -72.600 13.550 -71.850 ;
        RECT 16.350 -73.200 17.050 -72.500 ;
        RECT 18.350 -73.200 19.050 -69.300 ;
        RECT 19.600 -71.450 20.200 -69.300 ;
        RECT 51.450 -71.450 52.050 -62.650 ;
        RECT 54.150 -64.600 56.850 -63.900 ;
        RECT 61.950 -64.850 63.500 -63.850 ;
        RECT 19.600 -71.900 52.050 -71.450 ;
        RECT 48.750 -74.050 49.950 -72.750 ;
        RECT 35.100 -80.750 38.550 -75.950 ;
        RECT 35.100 -81.450 47.550 -80.750 ;
        RECT 35.100 -82.300 38.550 -81.450 ;
        RECT 17.350 -83.750 38.550 -82.300 ;
        RECT 35.100 -84.200 38.550 -83.750 ;
      LAYER met4 ;
        RECT 11.650 34.500 66.700 35.700 ;
        RECT -2.200 29.700 73.600 30.800 ;
        RECT -2.100 21.300 73.800 22.500 ;
        RECT -1.950 15.900 2.100 16.000 ;
        RECT -1.950 14.600 73.500 15.900 ;
        RECT -1.400 8.100 73.000 9.300 ;
        RECT -1.500 2.700 2.100 2.800 ;
        RECT -1.500 1.600 74.700 2.700 ;
        RECT 63.000 -28.350 74.400 -27.200 ;
        RECT 8.550 -30.900 29.150 -30.450 ;
        RECT 29.800 -30.900 31.000 -30.850 ;
        RECT 63.250 -30.900 65.800 -28.350 ;
        RECT 8.550 -31.800 65.800 -30.900 ;
        RECT 8.550 -41.500 10.100 -31.800 ;
        RECT 28.250 -32.250 65.800 -31.800 ;
        RECT 34.750 -38.000 38.900 -32.250 ;
        RECT 34.750 -39.250 46.550 -38.000 ;
        RECT 34.750 -39.300 54.400 -39.250 ;
        RECT 8.550 -42.500 12.600 -41.500 ;
        RECT 2.250 -52.100 3.850 -43.850 ;
        RECT 11.350 -49.100 12.600 -42.500 ;
        RECT 41.600 -51.750 43.050 -40.250 ;
        RECT 45.700 -40.600 54.400 -39.300 ;
        RECT 53.200 -44.850 54.400 -40.600 ;
        RECT 67.850 -44.150 74.900 -42.950 ;
        RECT 67.850 -46.650 69.300 -44.150 ;
        RECT 70.250 -46.500 71.250 -45.800 ;
        RECT 59.450 -50.850 69.250 -49.200 ;
        RECT 59.450 -51.750 61.000 -50.850 ;
        RECT 41.600 -53.400 61.000 -51.750 ;
        RECT 1.950 -65.200 3.550 -57.450 ;
        RECT 41.600 -63.050 43.050 -53.400 ;
        RECT 31.750 -64.750 39.050 -63.700 ;
        RECT 41.600 -64.300 45.050 -63.050 ;
        RECT 14.050 -66.950 23.950 -66.050 ;
        RECT 31.750 -66.950 33.400 -64.750 ;
        RECT 14.050 -67.100 33.400 -66.950 ;
        RECT 14.050 -71.700 15.750 -67.100 ;
        RECT 22.500 -68.550 33.400 -67.100 ;
        RECT 22.500 -68.600 27.100 -68.550 ;
        RECT 9.450 -72.700 15.750 -71.700 ;
        RECT 25.200 -70.800 27.000 -68.600 ;
        RECT 43.950 -68.950 45.050 -64.300 ;
        RECT 48.650 -63.900 49.900 -56.850 ;
        RECT 61.950 -63.900 63.500 -63.850 ;
        RECT 48.650 -64.750 63.500 -63.900 ;
        RECT 48.650 -64.850 56.800 -64.750 ;
        RECT 61.950 -64.850 63.500 -64.750 ;
        RECT 54.150 -70.800 56.800 -64.850 ;
        RECT 62.000 -65.000 63.450 -64.850 ;
        RECT 25.200 -72.350 56.800 -70.800 ;
        RECT 25.200 -72.450 56.600 -72.350 ;
        RECT 48.750 -74.050 49.950 -72.450 ;
        RECT 67.650 -87.900 69.250 -50.850 ;
        RECT 73.700 -79.650 74.900 -44.150 ;
  END
END newdene
END LIBRARY

